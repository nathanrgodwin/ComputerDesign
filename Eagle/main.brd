# Repository nathanrgodwin/ComputerDesign (continued)

## EAGLE design Eagle/main.brd (continued)

Schematic: main.sch, sheet 33, PC CLU

Parts:
IC286, IC287, IC288, IC289, IC290, IC291: 74HC00D; SO14

Connections:
GND: IC286.7 (GND), IC287.7 (GND), IC288.7 (GND), IC289.7 (GND), IC290.7 (GND), IC291.7 (GND); also elsewhere on the board
unnamed: IC286.3 (O), IC286.4 (I0)
unnamed: IC288.3 (O), IC288.4 (I0)
unnamed: IC286.8 (O), IC286.12 (I0)
unnamed: IC288.8 (O), IC288.12 (I0)
unnamed: IC287.3 (O), IC287.4 (I0)
unnamed: IC289.3 (O), IC289.4 (I0)
unnamed: IC287.8 (O), IC287.12 (I0)
unnamed: IC289.8 (O), IC289.12 (I0)
unnamed: IC290.3 (O), IC290.4 (I0)
unnamed: IC290.8 (O), IC290.12 (I0)
unnamed: IC291.3 (O), IC291.4 (I0)
unnamed: IC291.8 (O), IC291.12 (I0)
PCC3: IC286.1 (I0); also elsewhere on the board
PCC4: IC286.6 (O), IC286.9 (I0); also elsewhere on the board
PCC5: IC286.11 (O), IC287.1 (I0); also elsewhere on the board
PCC6: IC287.6 (O), IC287.9 (I0); also elsewhere on the board
PCC7: IC287.11 (O), IC288.1 (I0); also elsewhere on the board
PCC8: IC288.6 (O), IC288.9 (I0); also elsewhere on the board
PCC9: IC288.11 (O), IC289.1 (I0); also elsewhere on the board
PCC10: IC289.6 (O), IC289.9 (I0); also elsewhere on the board
PCC11: IC289.11 (O), IC290.1 (I0); also elsewhere on the board
PCC12: IC290.6 (O), IC290.9 (I0); also elsewhere on the board
PCC13: IC290.11 (O), IC291.1 (I0); also elsewhere on the board
PCC14: IC291.6 (O), IC291.9 (I0); also elsewhere on the board
PCC15: IC291.11 (O); also elsewhere on the board
PCGN3: IC286.5 (I1); also elsewhere on the board
PCGN4: IC286.13 (I1); also elsewhere on the board
PCGN5: IC287.5 (I1); also elsewhere on the board
PCGN6: IC287.13 (I1); also elsewhere on the board
PCGN7: IC288.5 (I1); also elsewhere on the board
PCGN8: IC288.13 (I1); also elsewhere on the board
PCGN9: IC289.5 (I1); also elsewhere on the board
PCGN10: IC289.13 (I1); also elsewhere on the board
PCGN11: IC290.5 (I1); also elsewhere on the board
PCGN12: IC290.13 (I1); also elsewhere on the board
PCGN13: IC291.5 (I1); also elsewhere on the board
PCGN14: IC291.13 (I1); also elsewhere on the board
PCP3: IC286.2 (I1); also elsewhere on the board
PCP4: IC286.10 (I1); also elsewhere on the board
PCP5: IC287.2 (I1); also elsewhere on the board
PCP6: IC287.10 (I1); also elsewhere on the board
PCP7: IC288.2 (I1); also elsewhere on the board
PCP8: IC288.10 (I1); also elsewhere on the board
PCP9: IC289.2 (I1); also elsewhere on the board
PCP10: IC289.10 (I1); also elsewhere on the board
PCP11: IC290.2 (I1); also elsewhere on the board
PCP12: IC290.10 (I1); also elsewhere on the board
PCP13: IC291.2 (I1); also elsewhere on the board
PCP14: IC291.10 (I1); also elsewhere on the board
VCC: IC286.14 (VCC), IC287.14 (VCC), IC288.14 (VCC), IC289.14 (VCC), IC290.14 (VCC), IC291.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 34, PC JAB SEL, OP DATA SELECTOR

Parts:
IC292, IC301, IC302, IC303, IC304, IC305: 74HC00D; SO14
IC293, IC294, IC295, IC296, IC297, IC298, IC299, IC300: 74HC125D; SO14

Connections:
A0: IC299.2 (I); also elsewhere on the board
A1: IC299.5 (I); also elsewhere on the board
A2: IC299.9 (I); also elsewhere on the board
A3: IC299.12 (I); also elsewhere on the board
A4: IC300.2 (I); also elsewhere on the board
A5: IC300.5 (I); also elsewhere on the board
A6: IC300.9 (I); also elsewhere on the board
A7: IC300.12 (I); also elsewhere on the board
B0: IC297.2 (I); also elsewhere on the board
B1: IC297.5 (I); also elsewhere on the board
B2: IC297.9 (I); also elsewhere on the board
B3: IC297.12 (I); also elsewhere on the board
B4: IC298.2 (I); also elsewhere on the board
B5: IC298.5 (I); also elsewhere on the board
B6: IC298.9 (I); also elsewhere on the board
B7: IC298.12 (I); also elsewhere on the board
CMD0: IC305.9 (I0), IC305.10 (I1); also elsewhere on the board
CMDN2: IC301.1 (I0); also elsewhere on the board
CMDN3: IC301.2 (I1); also elsewhere on the board
GND: IC292.7 (GND), IC293.7 (GND), IC294.7 (GND), IC295.7 (GND), IC296.7 (GND), IC297.7 (GND), IC298.7 (GND), IC299.7 (GND), IC300.7 (GND), IC301.7 (GND), IC302.7 (GND), IC303.7 (GND), IC304.7 (GND), IC305.7 (GND); also elsewhere on the board
JAB_EN: IC292.1 (I0), IC292.2 (I1), IC293.1 (OE), IC293.4 (OE), IC293.10 (OE), IC293.13 (OE), IC294.1 (OE), IC294.4 (OE), IC294.10 (OE), IC294.13 (OE), IC295.1 (OE), IC295.4 (OE), IC295.10 (OE), IC295.13 (OE), IC296.1 (OE), IC296.4 (OE), IC296.10 (OE), IC296.13 (OE); also elsewhere on the board
LOADSKIP: IC301.11 (O), IC302.4 (I0), IC302.9 (I0)
MULT_N: IC305.8 (O)
unnamed: IC303.3 (O), IC303.4 (I0), IC303.9 (I0)
unnamed: IC302.6 (O), IC303.1 (I0)
unnamed: IC292.3 (O), IC297.1 (OE), IC297.4 (OE), IC297.10 (OE), IC297.13 (OE), IC298.1 (OE), IC298.4 (OE), IC298.10 (OE), IC298.13 (OE), IC299.1 (OE), IC299.4 (OE), IC299.10 (OE), IC299.13 (OE), IC300.1 (OE), IC300.4 (OE), IC300.10 (OE), IC300.13 (OE)
unnamed: IC292.8 (O), IC292.12 (I0), IC292.13 (I1)
unnamed: IC292.11 (O), IC301.9 (I0)
unnamed: IC301.8 (O), IC301.12 (I0), IC301.13 (I1)
unnamed: IC301.3 (O), IC301.4 (I0), IC301.5 (I1)
unnamed: IC301.6 (O), IC301.10 (I1)
unnamed: IC302.11 (O), IC303.2 (I1)
unnamed: IC303.5 (I1), IC303.8 (O), IC303.12 (I0)
unnamed: IC303.6 (O), IC304.1 (I0)
unnamed: IC303.11 (O), IC304.2 (I1)
unnamed: IC302.5 (I1), IC302.8 (O), IC302.12 (I0)
OP11: IC305.12 (I0), IC305.13 (I1); also elsewhere on the board
OPCOUNTER0: IC302.3 (O), IC304.4 (I0), IC304.12 (I0)
OPCOUNTER1: IC304.3 (O)
OPCOUNTERLATCH0: IC292.9 (I0), IC302.1 (I0), IC302.2 (I1), IC303.10 (I1), IC303.13 (I1), IC304.9 (I0)
OPCOUNTERLATCH1: IC292.4 (I0), IC292.5 (I1), IC302.10 (I1), IC302.13 (I1), IC304.13 (I1)
OPCOUNTERLATCH1_: IC292.6 (O), IC292.10 (I1), IC304.5 (I1), IC304.10 (I1)
OPDATASELECTOR1: IC305.3 (O); also elsewhere on the board
OPDATASELECTOR2: IC305.6 (O)
OPDATASELECTOR_0: IC304.6 (O)
OPDATASELECTOR_1: IC304.8 (O), IC305.1 (I0), IC305.2 (I1)
OPDATASELECTOR_2: IC304.11 (O), IC305.4 (I0), IC305.5 (I1)
OPN11: IC305.11 (O); also elsewhere on the board
PC0: IC293.3 (O), IC297.3 (O)
PC1: IC293.6 (O), IC297.6 (O)
PC2: IC293.8 (O), IC297.8 (O)
PC3: IC293.11 (O), IC297.11 (O)
PC4: IC294.3 (O), IC298.3 (O)
PC5: IC294.6 (O), IC298.6 (O)
PC6: IC294.8 (O), IC298.8 (O)
PC7: IC294.11 (O), IC298.11 (O)
PC8: IC295.3 (O), IC299.3 (O)
PC9: IC295.6 (O), IC299.6 (O)
PC10: IC295.8 (O), IC299.8 (O)
PC11: IC295.11 (O), IC299.11 (O)
PC12: IC296.3 (O), IC300.3 (O)
PC13: IC296.6 (O), IC300.6 (O)
PC14: IC296.8 (O), IC300.8 (O)
PC15: IC296.11 (O), IC300.11 (O)
PC_PRE_JAB0: IC293.2 (I); also elsewhere on the board
PC_PRE_JAB1: IC293.5 (I); also elsewhere on the board
PC_PRE_JAB2: IC293.9 (I); also elsewhere on the board
PC_PRE_JAB3: IC293.12 (I); also elsewhere on the board
PC_PRE_JAB4: IC294.2 (I); also elsewhere on the board
PC_PRE_JAB5: IC294.5 (I); also elsewhere on the board
PC_PRE_JAB6: IC294.9 (I); also elsewhere on the board
PC_PRE_JAB7: IC294.12 (I); also elsewhere on the board
PC_PRE_JAB8: IC295.2 (I); also elsewhere on the board
PC_PRE_JAB9: IC295.5 (I); also elsewhere on the board
PC_PRE_JAB10: IC295.9 (I); also elsewhere on the board
PC_PRE_JAB11: IC295.12 (I); also elsewhere on the board
PC_PRE_JAB12: IC296.2 (I); also elsewhere on the board
PC_PRE_JAB13: IC296.5 (I); also elsewhere on the board
PC_PRE_JAB14: IC296.9 (I); also elsewhere on the board
PC_PRE_JAB15: IC296.12 (I); also elsewhere on the board
VCC: IC292.14 (VCC), IC293.14 (VCC), IC294.14 (VCC), IC295.14 (VCC), IC296.14 (VCC), IC297.14 (VCC), IC298.14 (VCC), IC299.14 (VCC), IC300.14 (VCC), IC301.14 (VCC), IC302.14 (VCC), IC303.14 (VCC), IC304.14 (VCC), IC305.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 36, REG_WR_SEL, REG_LIMIT_K

Parts:
IC306, IC307, IC308, IC309, IC310, IC311, IC312, IC313, IC314, IC315, IC316, IC317, IC318, IC319, IC320, IC321, IC322, IC323, IC324, IC325, IC326, IC327, IC328, IC329, IC330, IC331, IC332: 74HC00D; SO14

Connections:
GND: IC332.7 (GND); also elsewhere on the board
unnamed: IC306.11 (O), IC307.1 (I0), IC307.2 (I1)
unnamed: IC307.6 (O), IC307.9 (I0), IC307.10 (I1)
unnamed: IC308.3 (O), IC308.4 (I0), IC308.5 (I1)
unnamed: IC308.8 (O), IC308.12 (I0), IC308.13 (I1)
unnamed: IC309.6 (O), IC309.9 (I0), IC309.10 (I1)
unnamed: IC309.11 (O), IC310.1 (I0), IC310.2 (I1)
unnamed: IC310.8 (O), IC310.12 (I0), IC310.13 (I1)
unnamed: IC311.3 (O), IC311.4 (I0), IC311.5 (I1)
unnamed: IC311.11 (O), IC312.1 (I0), IC312.2 (I1)
unnamed: IC312.6 (O), IC312.9 (I0), IC312.10 (I1)
unnamed: IC313.3 (O), IC313.4 (I0), IC313.5 (I1)
unnamed: IC314.6 (O), IC314.9 (I0), IC314.10 (I1)
unnamed: IC313.8 (O), IC313.12 (I0), IC313.13 (I1)
unnamed: IC314.11 (O), IC315.1 (I0), IC315.2 (I1)
unnamed: IC315.3 (O), IC315.4 (I0)
unnamed: IC314.8 (O), IC315.5 (I1)
unnamed: IC313.11 (O), IC314.1 (I0)
unnamed: IC313.6 (O), IC314.2 (I1)
unnamed: IC312.8 (O), IC312.12 (I0)
unnamed: IC312.3 (O), IC312.13 (I1)
unnamed: IC311.6 (O), IC311.9 (I0)
unnamed: IC310.11 (O), IC311.10 (I1)
unnamed: IC310.3 (O), IC310.4 (I0)
unnamed: IC308.6 (O), IC309.2 (I1)
unnamed: IC308.11 (O), IC309.1 (I0)
unnamed: IC309.8 (O), IC310.5 (I1)
unnamed: IC307.3 (O), IC307.13 (I1)
unnamed: IC307.8 (O), IC307.12 (I0)
unnamed: IC315.8 (O), IC315.12 (I0), IC315.13 (I1)
unnamed: IC316.3 (O), IC316.4 (I0), IC316.5 (I1)
unnamed: IC316.11 (O), IC317.1 (I0), IC317.2 (I1)
unnamed: IC317.6 (O), IC317.9 (I0), IC317.10 (I1)
unnamed: IC318.3 (O), IC318.4 (I0), IC318.5 (I1)
unnamed: IC318.8 (O), IC318.12 (I0), IC318.13 (I1)
unnamed: IC319.6 (O), IC319.9 (I0), IC319.10 (I1)
unnamed: IC319.11 (O), IC320.1 (I0), IC320.2 (I1)
unnamed: IC320.8 (O), IC320.12 (I0), IC320.13 (I1)
unnamed: IC321.3 (O), IC321.4 (I0), IC321.5 (I1)
unnamed: IC321.11 (O), IC322.1 (I0), IC322.2 (I1)
unnamed: IC322.6 (O), IC322.9 (I0), IC322.10 (I1)
unnamed: IC323.3 (O), IC323.4 (I0), IC323.5 (I1)
unnamed: IC323.8 (O), IC323.12 (I0), IC323.13 (I1)
unnamed: IC323.11 (O), IC324.1 (I0)
unnamed: IC323.6 (O), IC324.2 (I1)
unnamed: IC322.8 (O), IC322.12 (I0)
unnamed: IC322.3 (O), IC322.13 (I1)
unnamed: IC321.6 (O), IC321.9 (I0)
unnamed: IC320.11 (O), IC321.10 (I1)
unnamed: IC320.3 (O), IC320.4 (I0)
unnamed: IC319.8 (O), IC320.5 (I1)
unnamed: IC318.11 (O), IC319.1 (I0)
unnamed: IC318.6 (O), IC319.2 (I1)
unnamed: IC317.8 (O), IC317.12 (I0)
unnamed: IC317.3 (O), IC317.13 (I1)
unnamed: IC316.6 (O), IC316.9 (I0)
unnamed: IC315.11 (O), IC316.10 (I1)
unnamed: IC325.8 (O), IC325.12 (I0)
unnamed: IC326.3 (O), IC326.4 (I0)
unnamed: IC326.8 (O), IC326.12 (I0)
unnamed: IC328.3 (O), IC328.4 (I0)
unnamed: IC306.14 (VCC), IC307.14 (VCC), IC308.14 (VCC), IC309.14 (VCC), IC310.14 (VCC), IC311.14 (VCC), IC312.14 (VCC), IC313.14 (VCC), IC314.14 (VCC), IC315.14 (VCC), IC316.14 (VCC), IC317.14 (VCC), IC318.14 (VCC), IC319.14 (VCC), IC320.14 (VCC), IC321.14 (VCC), IC322.14 (VCC), IC323.14 (VCC), IC324.14 (VCC), IC325.14 (VCC), IC326.14 (VCC), IC327.14 (VCC), IC328.14 (VCC), IC329.14 (VCC), IC330.14 (VCC), IC331.14 (VCC)
unnamed: IC324.6 (O), IC324.9 (I0), IC324.10 (I1)
unnamed: IC324.11 (O), IC325.1 (I0), IC325.2 (I1)
unnamed: IC324.8 (O), IC325.4 (I0)
unnamed: IC325.3 (O), IC325.5 (I1)
unnamed: IC327.3 (O), IC327.4 (I0)
unnamed: IC327.8 (O), IC327.12 (I0)
unnamed: IC306.7 (GND), IC307.7 (GND), IC308.7 (GND), IC309.7 (GND), IC310.7 (GND), IC311.7 (GND), IC312.7 (GND), IC313.7 (GND), IC314.7 (GND), IC315.7 (GND), IC316.7 (GND), IC317.7 (GND), IC318.7 (GND), IC319.7 (GND), IC320.7 (GND), IC321.7 (GND), IC322.7 (GND), IC323.7 (GND), IC324.7 (GND), IC325.7 (GND), IC326.7 (GND), IC327.7 (GND), IC328.7 (GND), IC329.7 (GND), IC330.7 (GND), IC331.7 (GND)
unnamed: IC328.8 (O), IC328.12 (I0)
unnamed: IC329.3 (O), IC329.4 (I0)
unnamed: IC329.8 (O), IC329.12 (I0)
unnamed: IC330.3 (O), IC330.4 (I0)
unnamed: IC330.8 (O), IC330.12 (I0)
unnamed: IC331.3 (O), IC331.4 (I0)
unnamed: IC331.8 (O), IC331.12 (I0)
unnamed: IC332.3 (O), IC332.4 (I0)
unnamed: IC332.8 (O), IC332.12 (I0)
OP8: IC306.9 (I0), IC306.10 (I1), IC308.9 (I0), IC311.1 (I0), IC313.9 (I0), IC316.1 (I0), IC318.9 (I0), IC321.1 (I0), IC324.12 (I0); also elsewhere on the board
OP9: IC306.4 (I0), IC306.5 (I1), IC309.13 (I1), IC311.2 (I1), IC314.13 (I1), IC316.2 (I1), IC319.13 (I1), IC321.2 (I1), IC323.10 (I1), IC324.13 (I1); also elsewhere on the board
OP10: IC306.1 (I0), IC306.2 (I1), IC311.12 (I0), IC313.1 (I0), IC314.4 (I0), IC315.9 (I0), IC321.12 (I0), IC323.1 (I0), IC324.4 (I0); also elsewhere on the board
OP11: IC316.13 (I1), IC318.2 (I1), IC319.5 (I1), IC320.10 (I1), IC321.13 (I1), IC323.2 (I1), IC324.5 (I1); also elsewhere on the board
OPN8: IC306.8 (O), IC307.4 (I0), IC309.12 (I0), IC312.4 (I0), IC314.12 (I0), IC317.4 (I0), IC319.12 (I0), IC322.4 (I0), IC323.9 (I0)
OPN9: IC306.6 (O), IC307.5 (I1), IC308.10 (I1), IC312.5 (I1), IC313.10 (I1), IC317.5 (I1), IC318.10 (I1), IC322.5 (I1)
OPN10: IC306.3 (O), IC306.12 (I0), IC308.1 (I0), IC309.4 (I0), IC310.9 (I0), IC316.12 (I0), IC318.1 (I0), IC319.4 (I0), IC320.9 (I0)
OPN11: IC306.13 (I1), IC308.2 (I1), IC309.5 (I1), IC310.10 (I1), IC311.13 (I1), IC313.2 (I1), IC314.5 (I1), IC315.10 (I1); also elsewhere on the board
REG_EN: IC325.13 (I1), IC326.5 (I1), IC326.13 (I1), IC327.5 (I1), IC327.13 (I1), IC328.5 (I1), IC328.13 (I1), IC329.5 (I1), IC329.13 (I1), IC330.5 (I1), IC330.13 (I1), IC331.5 (I1), IC331.13 (I1), IC332.5 (I1), IC332.13 (I1); also elsewhere on the board
REG_SEL_TEMP0: IC325.11 (O)
REG_SEL_TEMP1: IC326.6 (O)
REG_SEL_TEMP2: IC326.11 (O)
REG_SEL_TEMP3: IC327.6 (O)
REG_SEL_TEMP4: IC327.11 (O)
REG_SEL_TEMP5: IC328.6 (O)
REG_SEL_TEMP6: IC328.11 (O)
REG_SEL_TEMP7: IC329.6 (O)
REG_SEL_TEMP8: IC329.11 (O)
REG_SEL_TEMP9: IC330.6 (O)
REG_SEL_TEMP10: IC330.11 (O)
REG_SEL_TEMP11: IC331.6 (O)
REG_SEL_TEMP12: IC331.11 (O)
REG_SEL_TEMP14: IC332.6 (O)
REG_SEL_TEMP15: IC332.11 (O)
RSELN0: IC307.11 (O), IC325.9 (I0), IC325.10 (I1)
RSELN1: IC309.3 (O), IC326.1 (I0), IC326.2 (I1)
RSELN2: IC310.6 (O), IC326.9 (I0), IC326.10 (I1)
RSELN3: IC311.8 (O), IC327.1 (I0), IC327.2 (I1)
RSELN4: IC312.11 (O), IC327.9 (I0), IC327.10 (I1)
RSELN5: IC314.3 (O), IC328.1 (I0), IC328.2 (I1)
RSELN6: IC315.6 (O), IC328.9 (I0), IC328.10 (I1)
RSELN7: IC316.8 (O), IC329.1 (I0), IC329.2 (I1)
RSELN8: IC317.11 (O), IC329.9 (I0), IC329.10 (I1)
RSELN9: IC319.3 (O), IC330.1 (I0), IC330.2 (I1)
RSELN10: IC320.6 (O), IC330.9 (I0), IC330.10 (I1)
RSELN11: IC321.8 (O), IC331.1 (I0), IC331.2 (I1)
RSELN12: IC322.11 (O), IC331.9 (I0), IC331.10 (I1)
RSELN14: IC324.3 (O), IC332.1 (I0), IC332.2 (I1)
RSELN15: IC325.6 (O), IC332.9 (I0), IC332.10 (I1); also elsewhere on the board
VCC: IC332.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 37, OP_SELECT

Parts:
IC333, IC334, IC335, IC336, IC337, IC338, IC339, IC340, IC341, IC342, IC343, IC344, IC345, IC346, IC347, IC348, IC349, IC350, IC351, IC352, IC353, IC354, IC355, IC356, IC357, IC447, IC448: 74HC00D; SO14

Connections:
ADDSUB_SEL: IC341.8 (O), IC448.4 (I0), IC448.5 (I1)
ADDSUB_SEL_N: IC448.6 (O); also elsewhere on the board
AND_SEL: IC335.6 (O)
AND_SEL_N: IC335.3 (O), IC335.4 (I0), IC335.5 (I1); also elsewhere on the board
CMD0: IC347.6 (O); also elsewhere on the board
CMD1: IC347.11 (O); also elsewhere on the board
CMD2: IC350.6 (O)
CMD3: IC350.11 (O)
CMD4: IC353.6 (O)
CMD5: IC353.11 (O)
CMD6: IC447.11 (O); also elsewhere on the board
CMD6_0: IC356.6 (O), IC447.9 (I0)
CMD7: IC356.11 (O)
CMDN0: IC347.3 (O), IC347.4 (I0), IC347.5 (I1); also elsewhere on the board
CMDN1: IC347.8 (O), IC347.12 (I0), IC347.13 (I1)
CMDN2: IC350.3 (O), IC350.4 (I0), IC350.5 (I1), IC447.2 (I1); also elsewhere on the board
CMDN3: IC350.8 (O), IC350.12 (I0), IC350.13 (I1), IC447.1 (I0); also elsewhere on the board
CMDN4: IC353.3 (O), IC353.4 (I0), IC353.5 (I1), IC448.10 (I1)
CMDN5: IC353.8 (O), IC353.12 (I0), IC353.13 (I1), IC448.9 (I0)
CMDN6: IC356.3 (O), IC356.4 (I0), IC356.5 (I1)
CMDN7: IC356.8 (O), IC356.12 (I0), IC356.13 (I1); also elsewhere on the board
CMP_SEL: IC344.6 (O), IC344.9 (I0)
CSEL: IC448.8 (O), IC448.12 (I0), IC448.13 (I1); also elsewhere on the board
CSELN: IC448.11 (O); also elsewhere on the board
DATABUS4: IC448.1 (I0), IC448.2 (I1)
DATABUS5: IC354.9 (I0)
DATABUS6: IC354.2 (I1)
DATABUS7: IC354.1 (I0)
DATABUSN4: IC354.10 (I1), IC448.3 (O)
GND: IC333.7 (GND), IC334.7 (GND), IC335.7 (GND), IC336.7 (GND), IC337.7 (GND), IC338.7 (GND), IC339.7 (GND), IC340.7 (GND), IC341.7 (GND), IC342.7 (GND), IC343.7 (GND), IC344.7 (GND), IC345.7 (GND), IC346.7 (GND), IC347.7 (GND), IC348.7 (GND), IC349.7 (GND), IC350.7 (GND), IC351.7 (GND), IC352.7 (GND), IC353.7 (GND), IC354.7 (GND), IC355.7 (GND), IC356.7 (GND), IC357.7 (GND), IC447.7 (GND), IC448.7 (GND); also elsewhere on the board
unnamed: IC333.3 (O), IC333.4 (I0), IC333.5 (I1)
unnamed: IC333.8 (O), IC333.12 (I0), IC333.13 (I1)
unnamed: IC333.6 (O), IC335.1 (I0)
unnamed: IC333.11 (O), IC335.2 (I1)
unnamed: IC334.6 (O), IC335.9 (I0)
unnamed: IC334.11 (O), IC335.10 (I1)
unnamed: IC336.6 (O), IC338.1 (I0)
unnamed: IC336.11 (O), IC338.2 (I1)
unnamed: IC336.8 (O), IC336.12 (I0), IC336.13 (I1)
unnamed: IC336.3 (O), IC336.4 (I0), IC336.5 (I1)
unnamed: IC334.3 (O), IC334.4 (I0), IC334.5 (I1)
unnamed: IC334.8 (O), IC334.12 (I0), IC334.13 (I1)
unnamed: IC337.3 (O), IC337.4 (I0), IC337.5 (I1)
unnamed: IC337.8 (O), IC337.12 (I0), IC337.13 (I1)
unnamed: IC337.6 (O), IC338.9 (I0)
unnamed: IC337.11 (O), IC338.10 (I1)
unnamed: IC339.6 (O), IC341.1 (I0)
unnamed: IC339.11 (O), IC341.2 (I1)
unnamed: IC339.3 (O), IC339.4 (I0), IC339.5 (I1)
unnamed: IC339.8 (O), IC339.12 (I0), IC339.13 (I1)
unnamed: IC340.3 (O), IC340.4 (I0), IC340.5 (I1)
unnamed: IC340.8 (O), IC340.12 (I0), IC340.13 (I1)
unnamed: IC340.11 (O), IC341.5 (I1)
unnamed: IC340.6 (O), IC341.4 (I0)
unnamed: IC341.12 (I0), IC342.6 (O)
unnamed: IC341.13 (I1), IC342.11 (O)
unnamed: IC342.3 (O), IC342.4 (I0), IC342.5 (I1)
unnamed: IC342.8 (O), IC342.12 (I0), IC342.13 (I1)
unnamed: IC343.3 (O), IC343.4 (I0), IC343.5 (I1)
unnamed: IC343.8 (O), IC343.12 (I0), IC343.13 (I1)
unnamed: IC343.11 (O), IC344.5 (I1)
unnamed: IC343.6 (O), IC344.4 (I0)
unnamed: IC345.3 (O), IC345.4 (I0), IC345.5 (I1)
unnamed: IC345.8 (O), IC345.12 (I0), IC345.13 (I1)
unnamed: IC346.3 (O), IC346.4 (I0), IC346.5 (I1)
unnamed: IC346.8 (O), IC346.12 (I0), IC346.13 (I1)
unnamed: IC346.11 (O), IC347.10 (I1)
unnamed: IC346.6 (O), IC347.9 (I0)
unnamed: IC345.11 (O), IC347.2 (I1)
unnamed: IC345.6 (O), IC347.1 (I0)
unnamed: IC348.3 (O), IC348.4 (I0), IC348.5 (I1)
unnamed: IC348.8 (O), IC348.12 (I0), IC348.13 (I1)
unnamed: IC348.6 (O), IC350.1 (I0)
unnamed: IC348.11 (O), IC350.2 (I1)
unnamed: IC355.11 (O), IC356.10 (I1)
unnamed: IC355.6 (O), IC356.9 (I0)
unnamed: IC354.11 (O), IC356.2 (I1)
unnamed: IC354.6 (O), IC356.1 (I0)
unnamed: IC352.11 (O), IC353.10 (I1)
unnamed: IC352.6 (O), IC353.9 (I0)
unnamed: IC351.11 (O), IC353.2 (I1)
unnamed: IC351.6 (O), IC353.1 (I0)
unnamed: IC349.11 (O), IC350.10 (I1)
unnamed: IC349.6 (O), IC350.9 (I0)
unnamed: IC355.8 (O), IC355.12 (I0), IC355.13 (I1)
unnamed: IC355.3 (O), IC355.4 (I0), IC355.5 (I1)
unnamed: IC354.8 (O), IC354.12 (I0), IC354.13 (I1)
unnamed: IC354.3 (O), IC354.4 (I0), IC354.5 (I1)
unnamed: IC352.3 (O), IC352.4 (I0), IC352.5 (I1)
unnamed: IC352.8 (O), IC352.12 (I0), IC352.13 (I1)
unnamed: IC351.3 (O), IC351.4 (I0), IC351.5 (I1)
unnamed: IC351.8 (O), IC351.12 (I0), IC351.13 (I1)
unnamed: IC349.8 (O), IC349.12 (I0), IC349.13 (I1)
unnamed: IC349.3 (O), IC349.4 (I0), IC349.5 (I1)
unnamed: IC447.3 (O), IC447.4 (I0), IC447.5 (I1)
unnamed: IC447.6 (O), IC447.10 (I1)
unnamed: IC447.8 (O), IC447.12 (I0), IC447.13 (I1)
NOT_SEL: IC335.11 (O)
NOT_SEL_N: IC335.8 (O), IC335.12 (I0), IC335.13 (I1); also elsewhere on the board
OP2: IC344.12 (I0), IC344.13 (I1); also elsewhere on the board
OP12: IC334.10 (I1), IC337.10 (I1), IC340.10 (I1), IC343.10 (I1), IC346.10 (I1), IC349.10 (I1), IC352.10 (I1), IC355.10 (I1), IC357.1 (I0), IC357.2 (I1)
OP13: IC336.9 (I0), IC337.9 (I0), IC342.9 (I0), IC343.9 (I0), IC348.9 (I0), IC349.9 (I0), IC355.9 (I0), IC357.4 (I0), IC357.5 (I1)
OP14: IC339.2 (I1), IC340.2 (I1), IC342.2 (I1), IC343.2 (I1), IC351.2 (I1), IC352.2 (I1), IC355.2 (I1), IC357.9 (I0), IC357.10 (I1)
OP15: IC345.1 (I0), IC346.1 (I0), IC348.1 (I0), IC349.1 (I0), IC351.1 (I0), IC352.1 (I0), IC355.1 (I0), IC357.12 (I0), IC357.13 (I1)
OPN2: IC344.11 (O); also elsewhere on the board
OPN12: IC333.10 (I1), IC336.10 (I1), IC339.10 (I1), IC342.10 (I1), IC345.10 (I1), IC348.10 (I1), IC351.10 (I1), IC357.3 (O)
OPN13: IC333.9 (I0), IC334.9 (I0), IC339.9 (I0), IC340.9 (I0), IC345.9 (I0), IC346.9 (I0), IC351.9 (I0), IC352.9 (I0), IC357.6 (O)
OPN14: IC333.2 (I1), IC334.2 (I1), IC336.2 (I1), IC337.2 (I1), IC345.2 (I1), IC346.2 (I1), IC348.2 (I1), IC349.2 (I1), IC357.8 (O)
OPN15: IC333.1 (I0), IC334.1 (I0), IC336.1 (I0), IC337.1 (I0), IC339.1 (I0), IC340.1 (I0), IC342.1 (I0), IC343.1 (I0), IC357.11 (O)
OR_SEL: IC338.6 (O)
OR_SEL_N: IC338.3 (O), IC338.4 (I0), IC338.5 (I1); also elsewhere on the board
SHIFT_SEL: IC344.3 (O)
SHIFT_SEL_N: IC341.11 (O), IC344.1 (I0), IC344.2 (I1); also elsewhere on the board
SUB_SEL: IC344.8 (O); also elsewhere on the board
SUB_SEL_MID: IC344.10 (I1)
VCC: IC333.14 (VCC), IC334.14 (VCC), IC335.14 (VCC), IC336.14 (VCC), IC337.14 (VCC), IC338.14 (VCC), IC339.14 (VCC), IC340.14 (VCC), IC341.14 (VCC), IC342.14 (VCC), IC343.14 (VCC), IC344.14 (VCC), IC345.14 (VCC), IC346.14 (VCC), IC347.14 (VCC), IC348.14 (VCC), IC349.14 (VCC), IC350.14 (VCC), IC351.14 (VCC), IC352.14 (VCC), IC353.14 (VCC), IC354.14 (VCC), IC355.14 (VCC), IC356.14 (VCC), IC357.14 (VCC), IC447.14 (VCC), IC448.14 (VCC); also elsewhere on the board
XOR_SEL: IC338.11 (O)
XOR_SEL_N: IC338.8 (O), IC338.12 (I0), IC338.13 (I1); also elsewhere on the board

Schematic: main.sch, sheet 38, rsela

Parts:
IC358, IC359, IC360, IC361, IC362, IC363, IC364, IC365, IC366, IC367, IC368, IC369, IC370, IC371, IC372, IC373, IC374, IC375, IC376, IC377, IC378: 74HC00D; SO14

Connections:
GND: IC358.7 (GND), IC359.7 (GND), IC360.7 (GND), IC361.7 (GND), IC362.7 (GND), IC363.7 (GND), IC364.7 (GND), IC365.7 (GND), IC366.7 (GND), IC367.7 (GND), IC368.7 (GND), IC369.7 (GND), IC370.7 (GND), IC371.7 (GND), IC372.7 (GND), IC373.7 (GND), IC374.7 (GND), IC375.7 (GND), IC376.7 (GND), IC377.7 (GND), IC378.7 (GND); also elsewhere on the board
unnamed: IC377.6 (O), IC378.12 (I0)
unnamed: IC377.11 (O), IC378.13 (I1)
unnamed: IC377.8 (O), IC377.12 (I0), IC377.13 (I1)
unnamed: IC377.3 (O), IC377.4 (I0), IC377.5 (I1)
unnamed: IC376.8 (O), IC376.12 (I0), IC376.13 (I1)
unnamed: IC376.3 (O), IC376.4 (I0), IC376.5 (I1)
unnamed: IC375.8 (O), IC375.12 (I0), IC375.13 (I1)
unnamed: IC375.3 (O), IC375.4 (I0), IC375.5 (I1)
unnamed: IC374.8 (O), IC374.12 (I0), IC374.13 (I1)
unnamed: IC374.3 (O), IC374.4 (I0), IC374.5 (I1)
unnamed: IC372.8 (O), IC372.12 (I0), IC372.13 (I1)
unnamed: IC372.3 (O), IC372.4 (I0), IC372.5 (I1)
unnamed: IC371.8 (O), IC371.12 (I0), IC371.13 (I1)
unnamed: IC371.3 (O), IC371.4 (I0), IC371.5 (I1)
unnamed: IC370.8 (O), IC370.12 (I0), IC370.13 (I1)
unnamed: IC370.3 (O), IC370.4 (I0), IC370.5 (I1)
unnamed: IC369.8 (O), IC369.12 (I0), IC369.13 (I1)
unnamed: IC369.3 (O), IC369.4 (I0), IC369.5 (I1)
unnamed: IC369.6 (O), IC373.1 (I0)
unnamed: IC369.11 (O), IC373.2 (I1)
unnamed: IC370.6 (O), IC373.4 (I0)
unnamed: IC370.11 (O), IC373.5 (I1)
unnamed: IC371.6 (O), IC373.9 (I0)
unnamed: IC371.11 (O), IC373.10 (I1)
unnamed: IC372.6 (O), IC373.12 (I0)
unnamed: IC372.11 (O), IC373.13 (I1)
unnamed: IC374.6 (O), IC378.1 (I0)
unnamed: IC374.11 (O), IC378.2 (I1)
unnamed: IC375.6 (O), IC378.4 (I0)
unnamed: IC375.11 (O), IC378.5 (I1)
unnamed: IC376.6 (O), IC378.9 (I0)
unnamed: IC376.11 (O), IC378.10 (I1)
unnamed: IC358.3 (O), IC358.4 (I0), IC358.5 (I1)
unnamed: IC358.8 (O), IC358.12 (I0), IC358.13 (I1)
unnamed: IC359.3 (O), IC359.4 (I0), IC359.5 (I1)
unnamed: IC358.11 (O), IC363.2 (I1)
unnamed: IC358.6 (O), IC363.1 (I0)
unnamed: IC359.6 (O), IC363.4 (I0)
unnamed: IC359.11 (O), IC363.5 (I1)
unnamed: IC360.6 (O), IC363.9 (I0)
unnamed: IC360.11 (O), IC363.10 (I1)
unnamed: IC362.6 (O), IC363.12 (I0)
unnamed: IC362.11 (O), IC363.13 (I1)
unnamed: IC364.6 (O), IC368.1 (I0)
unnamed: IC364.11 (O), IC368.2 (I1)
unnamed: IC365.6 (O), IC368.4 (I0)
unnamed: IC365.11 (O), IC368.5 (I1)
unnamed: IC366.6 (O), IC368.9 (I0)
unnamed: IC366.11 (O), IC368.10 (I1)
unnamed: IC367.6 (O), IC368.12 (I0)
unnamed: IC367.11 (O), IC368.13 (I1)
unnamed: IC367.8 (O), IC367.12 (I0), IC367.13 (I1)
unnamed: IC367.3 (O), IC367.4 (I0), IC367.5 (I1)
unnamed: IC366.8 (O), IC366.12 (I0), IC366.13 (I1)
unnamed: IC366.3 (O), IC366.4 (I0), IC366.5 (I1)
unnamed: IC365.8 (O), IC365.12 (I0), IC365.13 (I1)
unnamed: IC365.3 (O), IC365.4 (I0), IC365.5 (I1)
unnamed: IC364.8 (O), IC364.12 (I0), IC364.13 (I1)
unnamed: IC364.3 (O), IC364.4 (I0), IC364.5 (I1)
unnamed: IC362.8 (O), IC362.12 (I0), IC362.13 (I1)
unnamed: IC362.3 (O), IC362.4 (I0), IC362.5 (I1)
unnamed: IC360.8 (O), IC360.12 (I0), IC360.13 (I1)
unnamed: IC360.3 (O), IC360.4 (I0), IC360.5 (I1)
unnamed: IC359.8 (O), IC359.12 (I0), IC359.13 (I1)
OP4: IC359.10 (I1), IC361.12 (I0), IC361.13 (I1), IC362.10 (I1), IC365.10 (I1), IC367.10 (I1), IC370.10 (I1), IC372.10 (I1), IC375.10 (I1), IC377.10 (I1); also elsewhere on the board
OP5: IC360.9 (I0), IC361.9 (I0), IC361.10 (I1), IC362.9 (I0), IC366.9 (I0), IC367.9 (I0), IC371.9 (I0), IC372.9 (I0), IC376.9 (I0), IC377.9 (I0); also elsewhere on the board
OP6: IC361.4 (I0), IC361.5 (I1), IC364.2 (I1), IC365.2 (I1), IC366.2 (I1), IC367.2 (I1), IC374.2 (I1), IC375.2 (I1), IC376.2 (I1), IC377.2 (I1); also elsewhere on the board
OP7: IC361.1 (I0), IC361.2 (I1), IC369.1 (I0), IC370.1 (I0), IC371.1 (I0), IC372.1 (I0), IC374.1 (I0), IC375.1 (I0), IC376.1 (I0), IC377.1 (I0); also elsewhere on the board
OPN4: IC358.10 (I1), IC360.10 (I1), IC361.11 (O), IC364.10 (I1), IC366.10 (I1), IC369.10 (I1), IC371.10 (I1), IC374.10 (I1), IC376.10 (I1)
OPN5: IC358.9 (I0), IC359.9 (I0), IC361.8 (O), IC364.9 (I0), IC365.9 (I0), IC369.9 (I0), IC370.9 (I0), IC374.9 (I0), IC375.9 (I0)
OPN6: IC358.2 (I1), IC359.2 (I1), IC360.2 (I1), IC361.6 (O), IC362.2 (I1), IC369.2 (I1), IC370.2 (I1), IC371.2 (I1), IC372.2 (I1)
OPN7: IC358.1 (I0), IC359.1 (I0), IC360.1 (I0), IC361.3 (O), IC362.1 (I0), IC364.1 (I0), IC365.1 (I0), IC366.1 (I0), IC367.1 (I0)
RSELA0: IC363.3 (O); also elsewhere on the board
RSELA1: IC363.6 (O); also elsewhere on the board
RSELA2: IC363.8 (O); also elsewhere on the board
RSELA3: IC363.11 (O); also elsewhere on the board
RSELA4: IC368.3 (O); also elsewhere on the board
RSELA5: IC368.6 (O); also elsewhere on the board
RSELA6: IC368.8 (O); also elsewhere on the board
RSELA7: IC368.11 (O); also elsewhere on the board
RSELA8: IC373.3 (O); also elsewhere on the board
RSELA9: IC373.6 (O); also elsewhere on the board
RSELA10: IC373.8 (O); also elsewhere on the board
RSELA11: IC373.11 (O); also elsewhere on the board
RSELA12: IC378.3 (O); also elsewhere on the board
RSELA13: IC378.6 (O); also elsewhere on the board
RSELA14: IC378.8 (O); also elsewhere on the board
RSELA15: IC378.11 (O); also elsewhere on the board
VCC: IC358.14 (VCC), IC359.14 (VCC), IC360.14 (VCC), IC361.14 (VCC), IC362.14 (VCC), IC363.14 (VCC), IC364.14 (VCC), IC365.14 (VCC), IC366.14 (VCC), IC367.14 (VCC), IC368.14 (VCC), IC369.14 (VCC), IC370.14 (VCC), IC371.14 (VCC), IC372.14 (VCC), IC373.14 (VCC), IC374.14 (VCC), IC375.14 (VCC), IC376.14 (VCC), IC377.14 (VCC), IC378.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 39, rselb

Parts:
IC379, IC380, IC381, IC383, IC384, IC385, IC386, IC387, IC388, IC389, IC390, IC391, IC392, IC393, IC394, IC395, IC396, IC397, IC398, IC399: 74HC00D; SO14

Connections:
GND: IC379.7 (GND), IC380.7 (GND), IC381.7 (GND), IC383.7 (GND), IC384.7 (GND), IC385.7 (GND), IC386.7 (GND), IC387.7 (GND), IC388.7 (GND), IC389.7 (GND), IC390.7 (GND), IC391.7 (GND), IC392.7 (GND), IC393.7 (GND), IC394.7 (GND), IC395.7 (GND), IC396.7 (GND), IC397.7 (GND), IC398.7 (GND), IC399.7 (GND); also elsewhere on the board
unnamed: IC398.6 (O), IC399.12 (I0)
unnamed: IC398.11 (O), IC399.13 (I1)
unnamed: IC398.8 (O), IC398.12 (I0), IC398.13 (I1)
unnamed: IC398.3 (O), IC398.4 (I0), IC398.5 (I1)
unnamed: IC397.8 (O), IC397.12 (I0), IC397.13 (I1)
unnamed: IC397.3 (O), IC397.4 (I0), IC397.5 (I1)
unnamed: IC396.8 (O), IC396.12 (I0), IC396.13 (I1)
unnamed: IC396.3 (O), IC396.4 (I0), IC396.5 (I1)
unnamed: IC395.8 (O), IC395.12 (I0), IC395.13 (I1)
unnamed: IC395.3 (O), IC395.4 (I0), IC395.5 (I1)
unnamed: IC393.8 (O), IC393.12 (I0), IC393.13 (I1)
unnamed: IC393.3 (O), IC393.4 (I0), IC393.5 (I1)
unnamed: IC392.8 (O), IC392.12 (I0), IC392.13 (I1)
unnamed: IC392.3 (O), IC392.4 (I0), IC392.5 (I1)
unnamed: IC391.8 (O), IC391.12 (I0), IC391.13 (I1)
unnamed: IC391.3 (O), IC391.4 (I0), IC391.5 (I1)
unnamed: IC390.8 (O), IC390.12 (I0), IC390.13 (I1)
unnamed: IC390.3 (O), IC390.4 (I0), IC390.5 (I1)
unnamed: IC390.6 (O), IC394.1 (I0)
unnamed: IC390.11 (O), IC394.2 (I1)
unnamed: IC391.6 (O), IC394.4 (I0)
unnamed: IC391.11 (O), IC394.5 (I1)
unnamed: IC392.6 (O), IC394.9 (I0)
unnamed: IC392.11 (O), IC394.10 (I1)
unnamed: IC393.6 (O), IC394.12 (I0)
unnamed: IC393.11 (O), IC394.13 (I1)
unnamed: IC395.6 (O), IC399.1 (I0)
unnamed: IC395.11 (O), IC399.2 (I1)
unnamed: IC396.6 (O), IC399.4 (I0)
unnamed: IC396.11 (O), IC399.5 (I1)
unnamed: IC397.6 (O), IC399.9 (I0)
unnamed: IC397.11 (O), IC399.10 (I1)
unnamed: IC379.3 (O), IC379.4 (I0), IC379.5 (I1)
unnamed: IC379.8 (O), IC379.12 (I0), IC379.13 (I1)
unnamed: IC380.3 (O), IC380.4 (I0), IC380.5 (I1)
unnamed: IC379.11 (O), IC384.2 (I1)
unnamed: IC379.6 (O), IC384.1 (I0)
unnamed: IC380.6 (O), IC384.4 (I0)
unnamed: IC380.11 (O), IC384.5 (I1)
unnamed: IC381.6 (O), IC384.9 (I0)
unnamed: IC381.11 (O), IC384.10 (I1)
unnamed: IC383.6 (O), IC384.12 (I0)
unnamed: IC383.11 (O), IC384.13 (I1)
unnamed: IC385.6 (O), IC389.1 (I0)
unnamed: IC385.11 (O), IC389.2 (I1)
unnamed: IC386.6 (O), IC389.4 (I0)
unnamed: IC386.11 (O), IC389.5 (I1)
unnamed: IC387.6 (O), IC389.9 (I0)
unnamed: IC387.11 (O), IC389.10 (I1)
unnamed: IC388.6 (O), IC389.12 (I0)
unnamed: IC388.11 (O), IC389.13 (I1)
unnamed: IC388.8 (O), IC388.12 (I0), IC388.13 (I1)
unnamed: IC388.3 (O), IC388.4 (I0), IC388.5 (I1)
unnamed: IC387.8 (O), IC387.12 (I0), IC387.13 (I1)
unnamed: IC387.3 (O), IC387.4 (I0), IC387.5 (I1)
unnamed: IC386.8 (O), IC386.12 (I0), IC386.13 (I1)
unnamed: IC386.3 (O), IC386.4 (I0), IC386.5 (I1)
unnamed: IC385.8 (O), IC385.12 (I0), IC385.13 (I1)
unnamed: IC385.3 (O), IC385.4 (I0), IC385.5 (I1)
unnamed: IC383.8 (O), IC383.12 (I0), IC383.13 (I1)
unnamed: IC383.3 (O), IC383.4 (I0), IC383.5 (I1)
unnamed: IC381.8 (O), IC381.12 (I0), IC381.13 (I1)
unnamed: IC381.3 (O), IC381.4 (I0), IC381.5 (I1)
unnamed: IC380.8 (O), IC380.12 (I0), IC380.13 (I1)
OP0: IC380.10 (I1), IC383.10 (I1), IC386.10 (I1), IC388.10 (I1), IC391.10 (I1), IC393.10 (I1), IC396.10 (I1), IC398.10 (I1); also elsewhere on the board
OP1: IC381.9 (I0), IC383.9 (I0), IC387.9 (I0), IC388.9 (I0), IC392.9 (I0), IC393.9 (I0), IC397.9 (I0), IC398.9 (I0); also elsewhere on the board
OP2: IC385.2 (I1), IC386.2 (I1), IC387.2 (I1), IC388.2 (I1), IC395.2 (I1), IC396.2 (I1), IC397.2 (I1), IC398.2 (I1); also elsewhere on the board
OP3: IC390.1 (I0), IC391.1 (I0), IC392.1 (I0), IC393.1 (I0), IC395.1 (I0), IC396.1 (I0), IC397.1 (I0), IC398.1 (I0); also elsewhere on the board
OPN0: IC379.10 (I1), IC381.10 (I1), IC385.10 (I1), IC387.10 (I1), IC390.10 (I1), IC392.10 (I1), IC395.10 (I1), IC397.10 (I1); also elsewhere on the board
OPN1: IC379.9 (I0), IC380.9 (I0), IC385.9 (I0), IC386.9 (I0), IC390.9 (I0), IC391.9 (I0), IC395.9 (I0), IC396.9 (I0); also elsewhere on the board
OPN2: IC379.2 (I1), IC380.2 (I1), IC381.2 (I1), IC383.2 (I1), IC390.2 (I1), IC391.2 (I1), IC392.2 (I1), IC393.2 (I1); also elsewhere on the board
OPN3: IC379.1 (I0), IC380.1 (I0), IC381.1 (I0), IC383.1 (I0), IC385.1 (I0), IC386.1 (I0), IC387.1 (I0), IC388.1 (I0); also elsewhere on the board
RSELB0: IC384.3 (O); also elsewhere on the board
RSELB1: IC384.6 (O); also elsewhere on the board
RSELB2: IC384.8 (O); also elsewhere on the board
RSELB3: IC384.11 (O); also elsewhere on the board
RSELB4: IC389.3 (O); also elsewhere on the board
RSELB5: IC389.6 (O); also elsewhere on the board
RSELB6: IC389.8 (O); also elsewhere on the board
RSELB7: IC389.11 (O); also elsewhere on the board
RSELB8: IC394.3 (O); also elsewhere on the board
RSELB9: IC394.6 (O); also elsewhere on the board
RSELB10: IC394.8 (O); also elsewhere on the board
RSELB11: IC394.11 (O); also elsewhere on the board
RSELB12: IC399.3 (O); also elsewhere on the board
RSELB13: IC399.6 (O); also elsewhere on the board
RSELB14: IC399.8 (O); also elsewhere on the board
RSELB15: IC399.11 (O); also elsewhere on the board
VCC: IC379.14 (VCC), IC380.14 (VCC), IC381.14 (VCC), IC383.14 (VCC), IC384.14 (VCC), IC385.14 (VCC), IC386.14 (VCC), IC387.14 (VCC), IC388.14 (VCC), IC389.14 (VCC), IC390.14 (VCC), IC391.14 (VCC), IC392.14 (VCC), IC393.14 (VCC), IC394.14 (VCC), IC395.14 (VCC), IC396.14 (VCC), IC397.14 (VCC), IC398.14 (VCC), IC399.14 (VCC); also elsewhere on the board
