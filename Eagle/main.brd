# Repository nathanrgodwin/ComputerDesign (continued)

## EAGLE design Eagle/main.brd (continued)

Schematic: main.sch, sheet 12, M_STAGE0, 9-5, Sign Extension Inverters, M_STAGE1, 11

Parts:
IC74, IC75, IC76, IC77, IC78, IC79, IC80, IC81, IC82, IC83: 74HC00D; SO14

Connections:
GND: IC74.7 (GND), IC75.7 (GND), IC76.7 (GND), IC77.7 (GND), IC78.7 (GND), IC79.7 (GND), IC80.7 (GND), IC81.7 (GND), IC82.7 (GND), IC83.7 (GND); also elsewhere on the board
unnamed: IC75.3 (O), IC75.4 (I0), IC75.12 (I0), IC79.2 (I1)
unnamed: IC75.10 (I1), IC75.11 (O)
unnamed: IC75.6 (O), IC75.9 (I0)
unnamed: IC75.8 (O), IC77.1 (I0), IC77.13 (I1)
unnamed: IC77.3 (O), IC77.4 (I0), IC77.12 (I0), IC79.1 (I0)
unnamed: IC77.6 (O), IC77.9 (I0)
unnamed: IC77.10 (I1), IC77.11 (O)
unnamed: IC79.5 (I1), IC80.3 (O), IC80.4 (I0), IC80.12 (I0)
unnamed: IC80.10 (I1), IC80.11 (O)
unnamed: IC80.6 (O), IC80.9 (I0)
unnamed: IC80.8 (O), IC82.1 (I0), IC82.13 (I1)
unnamed: IC79.4 (I0), IC82.3 (O), IC82.4 (I0), IC82.12 (I0)
unnamed: IC82.10 (I1), IC82.11 (O)
unnamed: IC82.6 (O), IC82.9 (I0)
unnamed: IC81.8 (O), IC83.1 (I0), IC83.13 (I1)
unnamed: IC79.9 (I0), IC83.3 (O), IC83.4 (I0), IC83.12 (I0)
unnamed: IC81.6 (O), IC81.9 (I0)
unnamed: IC81.10 (I1), IC81.11 (O)
unnamed: IC79.10 (I1), IC81.3 (O), IC81.4 (I0), IC81.12 (I0)
unnamed: IC83.6 (O), IC83.9 (I0)
unnamed: IC83.10 (I1), IC83.11 (O)
unnamed: IC78.6 (O), IC78.9 (I0)
unnamed: IC78.10 (I1), IC78.11 (O)
unnamed: IC78.3 (O), IC78.4 (I0), IC78.12 (I0), IC79.12 (I0)
unnamed: IC76.8 (O), IC78.1 (I0), IC78.13 (I1)
unnamed: IC76.6 (O), IC76.9 (I0)
unnamed: IC76.10 (I1), IC76.11 (O)
unnamed: IC76.3 (O), IC76.4 (I0), IC76.12 (I0), IC79.13 (I1)
PCC1: IC74.3 (O); also elsewhere on the board
PCGN0: IC74.1 (I0), IC74.2 (I1); also elsewhere on the board
PP0_8: IC76.1 (I0), IC76.13 (I1), IC80.1 (I0), IC80.13 (I1), IC81.1 (I0), IC81.13 (I1); also elsewhere on the board
PP0_SE_N: IC75.1 (I0), IC75.13 (I1); also elsewhere on the board
PP1_6: IC81.2 (I1), IC81.5 (I1); also elsewhere on the board
PP1_7: IC80.2 (I1), IC80.5 (I1); also elsewhere on the board
PP1_8: IC76.2 (I1), IC76.5 (I1); also elsewhere on the board
PP1_SE_N: IC75.2 (I1), IC75.5 (I1); also elsewhere on the board
PP2_4: IC83.2 (I1), IC83.5 (I1); also elsewhere on the board
PP2_5: IC82.2 (I1), IC82.5 (I1); also elsewhere on the board
PP2_6: IC78.2 (I1), IC78.5 (I1); also elsewhere on the board
PP2_7: IC77.2 (I1), IC77.5 (I1); also elsewhere on the board
PP2_8: IC74.9 (I0), IC74.10 (I1); also elsewhere on the board
PP3_7: IC74.4 (I0), IC74.5 (I1); also elsewhere on the board
PP3_8: IC74.12 (I0), IC74.13 (I1); also elsewhere on the board
VCC: IC74.14 (VCC), IC75.14 (VCC), IC76.14 (VCC), IC77.14 (VCC), IC78.14 (VCC), IC79.14 (VCC), IC80.14 (VCC), IC81.14 (VCC), IC82.14 (VCC), IC83.14 (VCC); also elsewhere on the board
W10: IC74.6 (O); also elsewhere on the board
W11: IC74.11 (O); also elsewhere on the board
X5: IC79.8 (O); also elsewhere on the board
X6: IC79.6 (O); also elsewhere on the board
X7: IC79.11 (O); also elsewhere on the board
X8: IC79.3 (O); also elsewhere on the board
Y5: IC83.8 (O); also elsewhere on the board
Y6: IC82.8 (O); also elsewhere on the board
Y7: IC78.8 (O); also elsewhere on the board
Y8: IC77.8 (O); also elsewhere on the board
Y9: IC74.8 (O); also elsewhere on the board

Notes on the sheet:
M_STAGE1, HA_1B10
M_STAGE0, HA_1B9
M_STAGE1, HA_1B11
M_STAGE0, FA8
M_STAGE0, FA6
M_STAGE0, FA7
M_STAGE0, FA5

Schematic: main.sch, sheet 13, M_STAGE0, 4-1

Parts:
IC84, IC85, IC86, IC87, IC88, IC89, IC90: 74HC00D; SO14

Connections:
GND: IC84.7 (GND), IC85.7 (GND), IC86.7 (GND), IC87.7 (GND), IC88.7 (GND), IC89.7 (GND), IC90.7 (GND); also elsewhere on the board
unnamed: IC84.3 (O), IC84.4 (I0), IC84.12 (I0), IC88.2 (I1)
unnamed: IC84.10 (I1), IC84.11 (O)
unnamed: IC84.6 (O), IC84.9 (I0)
unnamed: IC84.8 (O), IC86.1 (I0), IC86.13 (I1)
unnamed: IC86.3 (O), IC86.4 (I0), IC86.12 (I0), IC88.1 (I0)
unnamed: IC86.6 (O), IC86.9 (I0)
unnamed: IC86.10 (I1), IC86.11 (O)
unnamed: IC85.3 (O), IC85.4 (I0), IC85.12 (I0), IC88.5 (I1)
unnamed: IC85.6 (O), IC85.9 (I0)
unnamed: IC85.10 (I1), IC85.11 (O)
unnamed: IC85.8 (O), IC87.1 (I0), IC87.13 (I1)
unnamed: IC87.3 (O), IC87.4 (I0), IC87.12 (I0), IC88.4 (I0)
unnamed: IC87.10 (I1), IC87.11 (O)
unnamed: IC87.6 (O), IC87.9 (I0)
unnamed: IC88.12 (I0), IC88.13 (I1), IC90.3 (O), IC90.4 (I0), IC90.12 (I0)
unnamed: IC90.6 (O), IC90.9 (I0)
unnamed: IC90.10 (I1), IC90.11 (O)
unnamed: IC89.6 (O), IC89.9 (I0)
unnamed: IC89.10 (I1), IC89.11 (O)
unnamed: IC88.9 (I0), IC88.10 (I1), IC89.3 (O), IC89.4 (I0), IC89.12 (I0)
PP0_4: IC90.1 (I0), IC90.13 (I1); also elsewhere on the board
PP0_5: IC89.1 (I0), IC89.13 (I1); also elsewhere on the board
PP0_6: IC85.1 (I0), IC85.13 (I1); also elsewhere on the board
PP0_7: IC84.1 (I0), IC84.13 (I1); also elsewhere on the board
PP1_2: IC90.2 (I1), IC90.5 (I1); also elsewhere on the board
PP1_3: IC89.2 (I1), IC89.5 (I1); also elsewhere on the board
PP1_4: IC85.2 (I1), IC85.5 (I1); also elsewhere on the board
PP1_5: IC84.2 (I1), IC84.5 (I1); also elsewhere on the board
PP2_2: IC87.2 (I1), IC87.5 (I1); also elsewhere on the board
PP2_3: IC86.2 (I1), IC86.5 (I1); also elsewhere on the board
VCC: IC84.14 (VCC), IC85.14 (VCC), IC86.14 (VCC), IC87.14 (VCC), IC88.14 (VCC), IC89.14 (VCC), IC90.14 (VCC); also elsewhere on the board
X1: IC88.11 (O); also elsewhere on the board
X2: IC88.8 (O); also elsewhere on the board
X3: IC88.6 (O); also elsewhere on the board
X4: IC88.3 (O); also elsewhere on the board
Y1: IC90.8 (O); also elsewhere on the board
Y2: IC89.8 (O); also elsewhere on the board
Y3: IC87.8 (O); also elsewhere on the board
Y4: IC86.8 (O); also elsewhere on the board

Notes on the sheet:
M_STAGE0, FA4
M_STAGE0, FA3
M_STAGE0, HA2
M_STAGE0, HA1

Schematic: main.sch, sheet 14, M_STAGE1, 10-7, M_STAGE2, 0

Parts:
IC91, IC92, IC93, IC94, IC95, IC96, IC97, IC98, IC99: 74HC00D; SO14

Connections:
F0: IC93.8 (O); also elsewhere on the board
G0: IC95.3 (O); also elsewhere on the board
GND: IC91.7 (GND), IC92.7 (GND), IC93.7 (GND), IC94.7 (GND), IC95.7 (GND), IC96.7 (GND), IC97.7 (GND), IC98.7 (GND), IC99.7 (GND); also elsewhere on the board
unnamed: IC95.12 (I0), IC99.3 (O), IC99.4 (I0), IC99.12 (I0)
unnamed: IC99.6 (O), IC99.9 (I0)
unnamed: IC99.10 (I1), IC99.11 (O)
unnamed: IC97.8 (O), IC99.1 (I0), IC99.13 (I1)
unnamed: IC97.6 (O), IC97.9 (I0)
unnamed: IC97.10 (I1), IC97.11 (O)
unnamed: IC95.13 (I1), IC97.3 (O), IC97.4 (I0), IC97.12 (I0)
unnamed: IC94.6 (O), IC94.9 (I0)
unnamed: IC94.10 (I1), IC94.11 (O)
unnamed: IC94.3 (O), IC94.4 (I0), IC94.12 (I0), IC95.4 (I0)
unnamed: IC92.8 (O), IC94.1 (I0), IC94.13 (I1)
unnamed: IC92.6 (O), IC92.9 (I0)
unnamed: IC92.10 (I1), IC92.11 (O)
unnamed: IC92.3 (O), IC92.4 (I0), IC92.12 (I0), IC95.5 (I1)
unnamed: IC98.6 (O), IC98.9 (I0)
unnamed: IC98.10 (I1), IC98.11 (O)
unnamed: IC95.9 (I0), IC98.3 (O), IC98.4 (I0), IC98.12 (I0)
unnamed: IC96.8 (O), IC98.1 (I0), IC98.13 (I1)
unnamed: IC96.6 (O), IC96.9 (I0)
unnamed: IC96.10 (I1), IC96.11 (O)
unnamed: IC95.10 (I1), IC96.3 (O), IC96.4 (I0), IC96.12 (I0)
unnamed: IC93.6 (O), IC93.9 (I0)
unnamed: IC93.10 (I1), IC93.11 (O)
unnamed: IC93.3 (O), IC93.4 (I0), IC93.12 (I0), IC95.1 (I0)
unnamed: IC91.8 (O), IC93.1 (I0), IC93.13 (I1)
unnamed: IC91.6 (O), IC91.9 (I0)
unnamed: IC91.10 (I1), IC91.11 (O)
unnamed: IC91.3 (O), IC91.4 (I0), IC91.12 (I0), IC95.2 (I1)
PP3_4: IC97.2 (I1), IC97.5 (I1); also elsewhere on the board
PP3_5: IC96.2 (I1), IC96.5 (I1); also elsewhere on the board
PP3_6: IC92.2 (I1), IC92.5 (I1); also elsewhere on the board
VCC: IC91.14 (VCC), IC92.14 (VCC), IC93.14 (VCC), IC94.14 (VCC), IC95.14 (VCC), IC96.14 (VCC), IC97.14 (VCC), IC98.14 (VCC), IC99.14 (VCC); also elsewhere on the board
W3: IC91.1 (I0), IC91.13 (I1); also elsewhere on the board
W7: IC99.8 (O); also elsewhere on the board
W8: IC98.8 (O); also elsewhere on the board
W9: IC94.8 (O); also elsewhere on the board
X2: IC93.2 (I1), IC93.5 (I1); also elsewhere on the board
X6: IC99.2 (I1), IC99.5 (I1); also elsewhere on the board
X7: IC98.2 (I1), IC98.5 (I1); also elsewhere on the board
X8: IC94.2 (I1), IC94.5 (I1); also elsewhere on the board
Y7: IC97.1 (I0), IC97.13 (I1); also elsewhere on the board
Y8: IC96.1 (I0), IC96.13 (I1); also elsewhere on the board
Y9: IC92.1 (I0), IC92.13 (I1); also elsewhere on the board
Z2: IC91.2 (I1), IC91.5 (I1); also elsewhere on the board
Z7: IC95.11 (O); also elsewhere on the board
Z8: IC95.8 (O); also elsewhere on the board
Z9: IC95.6 (O); also elsewhere on the board

Notes on the sheet:
M_STAGE2, FA0
M_STAGE1, FA9
M_STAGE1, FA8
M_STAGE1, FA7

Schematic: main.sch, sheet 15, M_STAGE1, 6-3

Parts:
IC100, IC101, IC102, IC103, IC104, IC105, IC106, IC107, IC108: 74HC00D; SO14

Connections:
A7: IC108.2 (I1), IC108.5 (I1); also elsewhere on the board
GND: IC100.7 (GND), IC101.7 (GND), IC102.7 (GND), IC103.7 (GND), IC104.7 (GND), IC105.7 (GND), IC106.7 (GND), IC107.7 (GND), IC108.7 (GND); also elsewhere on the board
unnamed: IC104.12 (I0), IC108.3 (O), IC108.4 (I0), IC108.12 (I0)
unnamed: IC108.6 (O), IC108.9 (I0)
unnamed: IC108.10 (I1), IC108.11 (O)
unnamed: IC106.8 (O), IC108.1 (I0), IC108.13 (I1)
unnamed: IC106.6 (O), IC106.9 (I0)
unnamed: IC106.10 (I1), IC106.11 (O)
unnamed: IC104.13 (I1), IC106.3 (O), IC106.4 (I0), IC106.12 (I0)
unnamed: IC103.6 (O), IC103.9 (I0)
unnamed: IC103.10 (I1), IC103.11 (O)
unnamed: IC103.3 (O), IC103.4 (I0), IC103.12 (I0), IC104.4 (I0)
unnamed: IC101.8 (O), IC103.1 (I0), IC103.13 (I1)
unnamed: IC101.6 (O), IC101.9 (I0)
unnamed: IC101.10 (I1), IC101.11 (O)
unnamed: IC101.3 (O), IC101.4 (I0), IC101.12 (I0), IC104.5 (I1)
unnamed: IC107.6 (O), IC107.9 (I0)
unnamed: IC107.10 (I1), IC107.11 (O)
unnamed: IC104.9 (I0), IC107.3 (O), IC107.4 (I0), IC107.12 (I0)
unnamed: IC105.8 (O), IC107.1 (I0), IC107.13 (I1)
unnamed: IC105.6 (O), IC105.9 (I0)
unnamed: IC105.10 (I1), IC105.11 (O)
unnamed: IC104.10 (I1), IC105.3 (O), IC105.4 (I0), IC105.12 (I0)
unnamed: IC102.6 (O), IC102.9 (I0)
unnamed: IC102.10 (I1), IC102.11 (O)
unnamed: IC102.3 (O), IC102.4 (I0), IC102.12 (I0), IC104.1 (I0)
unnamed: IC100.8 (O), IC102.1 (I0), IC102.13 (I1)
unnamed: IC100.6 (O), IC100.9 (I0)
unnamed: IC100.10 (I1), IC100.11 (O)
unnamed: IC100.3 (O), IC100.4 (I0), IC100.12 (I0), IC104.2 (I1)
PP3_0: IC106.2 (I1), IC106.5 (I1); also elsewhere on the board
PP3_1: IC105.2 (I1), IC105.5 (I1); also elsewhere on the board
PP3_2: IC101.2 (I1), IC101.5 (I1); also elsewhere on the board
PP3_3: IC100.2 (I1), IC100.5 (I1); also elsewhere on the board
VCC: IC100.14 (VCC), IC101.14 (VCC), IC102.14 (VCC), IC103.14 (VCC), IC104.14 (VCC), IC105.14 (VCC), IC106.14 (VCC), IC107.14 (VCC), IC108.14 (VCC); also elsewhere on the board
W3: IC108.8 (O); also elsewhere on the board
W4: IC107.8 (O); also elsewhere on the board
W5: IC103.8 (O); also elsewhere on the board
W6: IC102.8 (O); also elsewhere on the board
X3: IC107.2 (I1), IC107.5 (I1); also elsewhere on the board
X4: IC103.2 (I1), IC103.5 (I1); also elsewhere on the board
X5: IC102.2 (I1), IC102.5 (I1); also elsewhere on the board
Y3: IC106.1 (I0), IC106.13 (I1); also elsewhere on the board
Y4: IC105.1 (I0), IC105.13 (I1); also elsewhere on the board
Y5: IC101.1 (I0), IC101.13 (I1); also elsewhere on the board
Y6: IC100.1 (I0), IC100.13 (I1); also elsewhere on the board
Z3: IC104.11 (O); also elsewhere on the board
Z4: IC104.8 (O); also elsewhere on the board
Z5: IC104.6 (O); also elsewhere on the board
Z6: IC104.3 (O); also elsewhere on the board

Notes on the sheet:
M_STAGE1, FA6
M_STAGE1, FA5
M_STAGE1, FA4
M_STAGE1, FA3

Schematic: main.sch, sheet 16, M_STAGE 0, 0, M_STAGE1, 2-1

Parts:
IC109, IC110, IC111, IC112, IC113, IC114, IC115: 74HC00D; SO14

Connections:
A5: IC114.2 (I1), IC114.5 (I1); also elsewhere on the board
GND: IC109.7 (GND), IC110.7 (GND), IC111.7 (GND), IC112.7 (GND), IC113.7 (GND), IC114.7 (GND), IC115.7 (GND); also elsewhere on the board
unnamed: IC111.13 (I1), IC113.3 (O), IC113.4 (I0), IC113.12 (I0)
unnamed: IC110.10 (I1), IC110.11 (O)
unnamed: IC110.6 (O), IC110.9 (I0)
unnamed: IC110.3 (O), IC110.4 (I0), IC110.12 (I0), IC111.4 (I0), IC111.5 (I1)
unnamed: IC109.3 (O), IC109.4 (I0), IC109.12 (I0), IC111.1 (I0), IC111.2 (I1)
unnamed: IC113.6 (O), IC113.9 (I0)
unnamed: IC109.6 (O), IC109.9 (I0)
unnamed: IC109.10 (I1), IC109.11 (O)
unnamed: IC113.10 (I1), IC113.11 (O)
unnamed: IC113.8 (O), IC115.1 (I0), IC115.13 (I1)
unnamed: IC111.12 (I0), IC115.3 (O), IC115.4 (I0), IC115.12 (I0)
unnamed: IC115.6 (O), IC115.9 (I0)
unnamed: IC115.10 (I1), IC115.11 (O)
unnamed: IC111.9 (I0), IC114.3 (O), IC114.4 (I0), IC114.12 (I0)
unnamed: IC114.10 (I1), IC114.11 (O)
unnamed: IC114.6 (O), IC114.9 (I0)
unnamed: IC112.8 (O), IC114.1 (I0), IC114.13 (I1)
unnamed: IC111.10 (I1), IC112.3 (O), IC112.4 (I0), IC112.12 (I0)
unnamed: IC112.6 (O), IC112.9 (I0)
unnamed: IC112.10 (I1), IC112.11 (O)
PP0_2: IC109.1 (I0), IC109.13 (I1); also elsewhere on the board
PP0_3: IC110.1 (I0), IC110.13 (I1); also elsewhere on the board
PP1_0: IC109.2 (I1), IC109.5 (I1); also elsewhere on the board
PP1_1: IC110.2 (I1), IC110.5 (I1); also elsewhere on the board
PP2_0: IC112.2 (I1), IC112.5 (I1); also elsewhere on the board
PP2_1: IC113.2 (I1), IC113.5 (I1); also elsewhere on the board
VCC: IC109.14 (VCC), IC110.14 (VCC), IC111.14 (VCC), IC112.14 (VCC), IC113.14 (VCC), IC114.14 (VCC), IC115.14 (VCC); also elsewhere on the board
W0: IC110.8 (O); also elsewhere on the board
W1: IC114.8 (O); also elsewhere on the board
W2: IC115.8 (O); also elsewhere on the board
X0: IC111.3 (O); also elsewhere on the board
X1: IC115.2 (I1), IC115.5 (I1); also elsewhere on the board
Y0: IC109.8 (O); also elsewhere on the board
Y1: IC112.1 (I0), IC112.13 (I1); also elsewhere on the board
Y2: IC113.1 (I0), IC113.13 (I1); also elsewhere on the board
Z0: IC111.6 (O); also elsewhere on the board
Z1: IC111.8 (O); also elsewhere on the board
Z2: IC111.11 (O); also elsewhere on the board

Notes on the sheet:
M_STAGE0, HA0
M_STAGE1, HA0
M_STAGE1, FA1
M_STAGE1, FA2

Schematic: main.sch, sheet 17, M_STAGE2, 8-5

Parts:
IC116, IC117, IC118, IC119, IC120: 74HC00D; SO14

Connections:
F5: IC120.8 (O); also elsewhere on the board
F6: IC119.8 (O); also elsewhere on the board
F7: IC117.8 (O); also elsewhere on the board
F8: IC116.8 (O); also elsewhere on the board
G5: IC118.11 (O); also elsewhere on the board
G6: IC118.8 (O); also elsewhere on the board
G7: IC118.6 (O); also elsewhere on the board
G8: IC118.3 (O); also elsewhere on the board
GND: IC116.7 (GND), IC117.7 (GND), IC118.7 (GND), IC119.7 (GND), IC120.7 (GND); also elsewhere on the board
unnamed: IC116.3 (O), IC116.4 (I0), IC116.12 (I0), IC118.1 (I0), IC118.2 (I1)
unnamed: IC116.10 (I1), IC116.11 (O)
unnamed: IC116.6 (O), IC116.9 (I0)
unnamed: IC117.10 (I1), IC117.11 (O)
unnamed: IC117.6 (O), IC117.9 (I0)
unnamed: IC117.3 (O), IC117.4 (I0), IC117.12 (I0), IC118.4 (I0), IC118.5 (I1)
unnamed: IC118.12 (I0), IC118.13 (I1), IC120.3 (O), IC120.4 (I0), IC120.12 (I0)
unnamed: IC120.6 (O), IC120.9 (I0)
unnamed: IC120.10 (I1), IC120.11 (O)
unnamed: IC119.6 (O), IC119.9 (I0)
unnamed: IC119.10 (I1), IC119.11 (O)
unnamed: IC118.9 (I0), IC118.10 (I1), IC119.3 (O), IC119.4 (I0), IC119.12 (I0)
PP3_7: IC116.2 (I1), IC116.5 (I1); also elsewhere on the board
VCC: IC116.14 (VCC), IC117.14 (VCC), IC118.14 (VCC), IC119.14 (VCC), IC120.14 (VCC); also elsewhere on the board
W8: IC120.1 (I0), IC120.13 (I1); also elsewhere on the board
W9: IC119.1 (I0), IC119.13 (I1); also elsewhere on the board
W10: IC117.1 (I0), IC117.13 (I1); also elsewhere on the board
W11: IC116.1 (I0), IC116.13 (I1); also elsewhere on the board
Z7: IC120.2 (I1), IC120.5 (I1); also elsewhere on the board
Z8: IC119.2 (I1), IC119.5 (I1); also elsewhere on the board
Z9: IC117.2 (I1), IC117.5 (I1); also elsewhere on the board

Notes on the sheet:
M_STAGE2, HA8
M_STAGE2, HA7
M_STAGE2, HA6
M_STAGE2, HA5

Schematic: main.sch, sheet 18, M_STAGE2, 4-1

Parts:
IC121, IC122, IC123, IC124, IC125: 74HC00D; SO14

Connections:
F1: IC125.8 (O); also elsewhere on the board
F2: IC124.8 (O); also elsewhere on the board
F3: IC122.8 (O); also elsewhere on the board
F4: IC121.8 (O); also elsewhere on the board
G1: IC123.11 (O); also elsewhere on the board
G2: IC123.8 (O); also elsewhere on the board
G3: IC123.6 (O); also elsewhere on the board
G4: IC123.3 (O); also elsewhere on the board
GND: IC121.7 (GND), IC122.7 (GND), IC123.7 (GND), IC124.7 (GND), IC125.7 (GND); also elsewhere on the board
unnamed: IC121.3 (O), IC121.4 (I0), IC121.12 (I0), IC123.1 (I0), IC123.2 (I1)
unnamed: IC121.10 (I1), IC121.11 (O)
unnamed: IC121.6 (O), IC121.9 (I0)
unnamed: IC122.10 (I1), IC122.11 (O)
unnamed: IC122.6 (O), IC122.9 (I0)
unnamed: IC122.3 (O), IC122.4 (I0), IC122.12 (I0), IC123.4 (I0), IC123.5 (I1)
unnamed: IC123.12 (I0), IC123.13 (I1), IC125.3 (O), IC125.4 (I0), IC125.12 (I0)
unnamed: IC125.6 (O), IC125.9 (I0)
unnamed: IC125.10 (I1), IC125.11 (O)
unnamed: IC124.6 (O), IC124.9 (I0)
unnamed: IC124.10 (I1), IC124.11 (O)
unnamed: IC123.9 (I0), IC123.10 (I1), IC124.3 (O), IC124.4 (I0), IC124.12 (I0)
VCC: IC121.14 (VCC), IC122.14 (VCC), IC123.14 (VCC), IC124.14 (VCC), IC125.14 (VCC); also elsewhere on the board
W4: IC125.1 (I0), IC125.13 (I1); also elsewhere on the board
W5: IC124.1 (I0), IC124.13 (I1); also elsewhere on the board
W6: IC122.1 (I0), IC122.13 (I1); also elsewhere on the board
W7: IC121.1 (I0), IC121.13 (I1); also elsewhere on the board
Z3: IC125.2 (I1), IC125.5 (I1); also elsewhere on the board
Z4: IC124.2 (I1), IC124.5 (I1); also elsewhere on the board
Z5: IC122.2 (I1), IC122.5 (I1); also elsewhere on the board
Z6: IC121.2 (I1), IC121.5 (I1); also elsewhere on the board

Notes on the sheet:
M_STAGE2, HA4
M_STAGE2, HA3
M_STAGE2, HA2
M_STAGE2, HA1

Schematic: main.sch, sheet 19, CLA_MULT 0, 1, 6

Parts:
IC126, IC127, IC128: 74HC00D; SO14

Connections:
A1: IC126.2 (I1), IC126.5 (I1); also elsewhere on the board
C1: IC128.2 (I1), IC128.5 (I1); also elsewhere on the board
C6: IC127.2 (I1), IC127.5 (I1); also elsewhere on the board
F0: IC127.1 (I0), IC127.13 (I1); also elsewhere on the board
GND: IC126.7 (GND), IC127.7 (GND), IC128.7 (GND); also elsewhere on the board
G_N0: IC126.3 (O), IC126.4 (I0), IC126.12 (I0); also elsewhere on the board
unnamed: IC127.10 (I1), IC127.11 (O)
unnamed: IC126.10 (I1), IC126.11 (O)
unnamed: IC126.6 (O), IC126.9 (I0)
unnamed: IC128.3 (O), IC128.4 (I0), IC128.12 (I0)
unnamed: IC127.6 (O), IC127.9 (I0)
unnamed: IC128.6 (O), IC128.9 (I0)
unnamed: IC128.10 (I1), IC128.11 (O)
unnamed: IC127.3 (O), IC127.4 (I0), IC127.12 (I0)
PP0_0: IC126.1 (I0), IC126.13 (I1); also elsewhere on the board
PP0_1: IC128.1 (I0), IC128.13 (I1); also elsewhere on the board
PROD0: IC126.8 (O); also elsewhere on the board
PROD1: IC128.8 (O); also elsewhere on the board
PROD6: IC127.8 (O); also elsewhere on the board
VCC: IC126.14 (VCC), IC127.14 (VCC), IC128.14 (VCC); also elsewhere on the board

Notes on the sheet:
CLA_MULT 0
CLA_MULT 1
CLA_MULT 6

Schematic: main.sch, sheet 20, CLA_MULT 14-11

Parts:
IC129, IC130, IC131, IC132, IC133, IC134, IC135, IC136, IC137, IC138, IC139: 74HC00D; SO14

Connections:
C11: IC138.2 (I1), IC138.5 (I1); also elsewhere on the board
C12: IC133.2 (I1), IC133.5 (I1); also elsewhere on the board
C13: IC139.2 (I1), IC139.5 (I1); also elsewhere on the board
C14: IC134.2 (I1), IC134.5 (I1); also elsewhere on the board
F5: IC132.4 (I0), IC132.5 (I1), IC135.1 (I0), IC135.13 (I1); also elsewhere on the board
F6: IC129.1 (I0), IC129.13 (I1), IC137.9 (I0), IC137.10 (I1); also elsewhere on the board
F7: IC131.12 (I0), IC131.13 (I1), IC136.1 (I0), IC136.13 (I1); also elsewhere on the board
F8: IC130.1 (I0), IC130.13 (I1), IC131.1 (I0), IC131.2 (I1); also elsewhere on the board
G4: IC132.9 (I0), IC132.10 (I1), IC135.2 (I1), IC135.5 (I1); also elsewhere on the board
G5: IC129.2 (I1), IC129.5 (I1), IC137.12 (I0), IC137.13 (I1); also elsewhere on the board
G6: IC136.2 (I1), IC136.5 (I1), IC137.1 (I0), IC137.2 (I1); also elsewhere on the board
G7: IC130.2 (I1), IC130.5 (I1), IC131.4 (I0), IC131.5 (I1); also elsewhere on the board
GND: IC129.7 (GND), IC130.7 (GND), IC131.7 (GND), IC132.7 (GND), IC133.7 (GND), IC134.7 (GND), IC135.7 (GND), IC136.7 (GND), IC137.7 (GND), IC138.7 (GND), IC139.7 (GND); also elsewhere on the board
G_N11: IC135.3 (O), IC135.4 (I0), IC135.12 (I0); also elsewhere on the board
G_N12: IC129.3 (O), IC129.4 (I0), IC129.12 (I0); also elsewhere on the board
G_N13: IC136.3 (O), IC136.4 (I0), IC136.12 (I0); also elsewhere on the board
G_N14: IC130.3 (O), IC130.4 (I0), IC130.12 (I0); also elsewhere on the board
unnamed: IC134.6 (O), IC134.9 (I0)
unnamed: IC134.10 (I1), IC134.11 (O)
unnamed: IC134.3 (O), IC134.4 (I0), IC134.12 (I0)
unnamed: IC130.8 (O), IC134.1 (I0), IC134.13 (I1)
unnamed: IC130.6 (O), IC130.9 (I0)
unnamed: IC130.10 (I1), IC130.11 (O)
unnamed: IC136.10 (I1), IC136.11 (O)
unnamed: IC136.6 (O), IC136.9 (I0)
unnamed: IC136.8 (O), IC139.1 (I0), IC139.13 (I1)
unnamed: IC139.3 (O), IC139.4 (I0), IC139.12 (I0)
unnamed: IC139.6 (O), IC139.9 (I0)
unnamed: IC139.10 (I1), IC139.11 (O)
unnamed: IC133.3 (O), IC133.4 (I0), IC133.12 (I0)
unnamed: IC129.8 (O), IC133.1 (I0), IC133.13 (I1)
unnamed: IC133.10 (I1), IC133.11 (O)
unnamed: IC133.6 (O), IC133.9 (I0)
unnamed: IC129.10 (I1), IC129.11 (O)
unnamed: IC129.6 (O), IC129.9 (I0)
unnamed: IC135.6 (O), IC135.9 (I0)
unnamed: IC135.10 (I1), IC135.11 (O)
unnamed: IC131.3 (O), IC131.9 (I0)
unnamed: IC135.8 (O), IC138.1 (I0), IC138.13 (I1)
unnamed: IC138.3 (O), IC138.4 (I0), IC138.12 (I0)
unnamed: IC138.6 (O), IC138.9 (I0)
unnamed: IC138.10 (I1), IC138.11 (O)
unnamed: IC131.6 (O), IC131.10 (I1)
unnamed: IC137.3 (O), IC137.5 (I1)
unnamed: IC131.11 (O), IC137.4 (I0)
unnamed: IC132.2 (I1), IC137.11 (O)
unnamed: IC132.1 (I0), IC137.8 (O)
unnamed: IC132.8 (O), IC132.13 (I1)
unnamed: IC132.6 (O), IC132.12 (I0)
P11: IC132.11 (O); also elsewhere on the board
P12: IC132.3 (O); also elsewhere on the board
P13: IC137.6 (O); also elsewhere on the board
P14: IC131.8 (O); also elsewhere on the board
PROD11: IC138.8 (O)
PROD12: IC133.8 (O)
PROD13: IC139.8 (O)
PROD14: IC134.8 (O)
VCC: IC129.14 (VCC), IC130.14 (VCC), IC131.14 (VCC), IC132.14 (VCC), IC133.14 (VCC), IC134.14 (VCC), IC135.14 (VCC), IC136.14 (VCC), IC137.14 (VCC), IC138.14 (VCC), IC139.14 (VCC); also elsewhere on the board

Notes on the sheet:
CLA_MULT 14
CLA_MULT 13
CLA_MULT 12
CLA_MULT 11

Schematic: main.sch, sheet 21, CLA_MULT 10-7

Parts:
IC140, IC141, IC142, IC143, IC144, IC145, IC146, IC147, IC148, IC149, IC150: 74HC00D; SO14

Connections:
C7: IC149.2 (I1), IC149.5 (I1); also elsewhere on the board
C8: IC144.2 (I1), IC144.5 (I1); also elsewhere on the board
C9: IC150.2 (I1), IC150.5 (I1); also elsewhere on the board
C10: IC145.2 (I1), IC145.5 (I1); also elsewhere on the board
F1: IC143.4 (I0), IC143.5 (I1), IC146.1 (I0), IC146.13 (I1); also elsewhere on the board
F2: IC140.1 (I0), IC140.13 (I1), IC148.9 (I0), IC148.10 (I1); also elsewhere on the board
F3: IC142.12 (I0), IC142.13 (I1), IC147.1 (I0), IC147.13 (I1); also elsewhere on the board
F4: IC141.1 (I0), IC141.13 (I1), IC142.1 (I0), IC142.2 (I1); also elsewhere on the board
G0: IC143.9 (I0), IC143.10 (I1), IC146.2 (I1), IC146.5 (I1); also elsewhere on the board
G1: IC140.2 (I1), IC140.5 (I1), IC148.12 (I0), IC148.13 (I1); also elsewhere on the board
G2: IC147.2 (I1), IC147.5 (I1), IC148.1 (I0), IC148.2 (I1); also elsewhere on the board
G3: IC141.2 (I1), IC141.5 (I1), IC142.4 (I0), IC142.5 (I1); also elsewhere on the board
GND: IC140.7 (GND), IC141.7 (GND), IC142.7 (GND), IC143.7 (GND), IC144.7 (GND), IC145.7 (GND), IC146.7 (GND), IC147.7 (GND), IC148.7 (GND), IC149.7 (GND), IC150.7 (GND); also elsewhere on the board
G_N7: IC146.3 (O), IC146.4 (I0), IC146.12 (I0); also elsewhere on the board
G_N8: IC140.3 (O), IC140.4 (I0), IC140.12 (I0); also elsewhere on the board
G_N9: IC147.3 (O), IC147.4 (I0), IC147.12 (I0); also elsewhere on the board
G_N10: IC141.3 (O), IC141.4 (I0), IC141.12 (I0); also elsewhere on the board
unnamed: IC145.6 (O), IC145.9 (I0)
unnamed: IC145.10 (I1), IC145.11 (O)
unnamed: IC145.3 (O), IC145.4 (I0), IC145.12 (I0)
unnamed: IC141.6 (O), IC141.9 (I0)
unnamed: IC141.10 (I1), IC141.11 (O)
unnamed: IC141.8 (O), IC145.1 (I0), IC145.13 (I1)
unnamed: IC147.10 (I1), IC147.11 (O)
unnamed: IC147.6 (O), IC147.9 (I0)
unnamed: IC147.8 (O), IC150.1 (I0), IC150.13 (I1)
unnamed: IC150.3 (O), IC150.4 (I0), IC150.12 (I0)
unnamed: IC150.6 (O), IC150.9 (I0)
unnamed: IC150.10 (I1), IC150.11 (O)
unnamed: IC144.3 (O), IC144.4 (I0), IC144.12 (I0)
unnamed: IC140.8 (O), IC144.1 (I0), IC144.13 (I1)
unnamed: IC144.10 (I1), IC144.11 (O)
unnamed: IC144.6 (O), IC144.9 (I0)
unnamed: IC140.10 (I1), IC140.11 (O)
unnamed: IC140.6 (O), IC140.9 (I0)
unnamed: IC146.6 (O), IC146.9 (I0)
unnamed: IC146.10 (I1), IC146.11 (O)
unnamed: IC146.8 (O), IC149.1 (I0), IC149.13 (I1)
unnamed: IC149.3 (O), IC149.4 (I0), IC149.12 (I0)
unnamed: IC149.6 (O), IC149.9 (I0)
unnamed: IC149.10 (I1), IC149.11 (O)
unnamed: IC142.3 (O), IC142.9 (I0)
unnamed: IC142.6 (O), IC142.10 (I1)
unnamed: IC148.3 (O), IC148.5 (I1)
unnamed: IC142.11 (O), IC148.4 (I0)
unnamed: IC143.2 (I1), IC148.11 (O)
unnamed: IC143.1 (I0), IC148.8 (O)
unnamed: IC143.8 (O), IC143.13 (I1)
unnamed: IC143.6 (O), IC143.12 (I0)
P7: IC143.11 (O); also elsewhere on the board
P8: IC143.3 (O); also elsewhere on the board
P9: IC148.6 (O); also elsewhere on the board
P10: IC142.8 (O); also elsewhere on the board
PROD7: IC149.8 (O); also elsewhere on the board
PROD8: IC144.8 (O)
PROD9: IC150.8 (O)
PROD10: IC145.8 (O)
VCC: IC140.14 (VCC), IC141.14 (VCC), IC142.14 (VCC), IC143.14 (VCC), IC144.14 (VCC), IC145.14 (VCC), IC146.14 (VCC), IC147.14 (VCC), IC148.14 (VCC), IC149.14 (VCC), IC150.14 (VCC); also elsewhere on the board

Notes on the sheet:
CLA_MULT 10
CLA_MULT 9
CLA_MULT 8
CLA_MULT 7

Schematic: main.sch, sheet 22, CLA_MULT 5-2

Parts:
IC151, IC152, IC153, IC154, IC155, IC156, IC157, IC158, IC159, IC160, IC161: 74HC00D; SO14

Connections:
A3: IC154.9 (I0), IC154.10 (I1), IC157.2 (I1), IC157.5 (I1); also elsewhere on the board
C2: IC160.2 (I1), IC160.5 (I1); also elsewhere on the board
C3: IC155.2 (I1), IC155.5 (I1); also elsewhere on the board
C4: IC161.2 (I1), IC161.5 (I1); also elsewhere on the board
C5: IC156.2 (I1), IC156.5 (I1); also elsewhere on the board
GND: IC151.7 (GND), IC152.7 (GND), IC153.7 (GND), IC154.7 (GND), IC155.7 (GND), IC156.7 (GND), IC157.7 (GND), IC158.7 (GND), IC159.7 (GND), IC160.7 (GND), IC161.7 (GND); also elsewhere on the board
G_N2: IC157.3 (O), IC157.4 (I0), IC157.12 (I0); also elsewhere on the board
G_N3: IC151.3 (O), IC151.4 (I0), IC151.12 (I0); also elsewhere on the board
G_N4: IC158.3 (O), IC158.4 (I0), IC158.12 (I0); also elsewhere on the board
G_N5: IC152.3 (O), IC152.4 (I0), IC152.12 (I0); also elsewhere on the board
unnamed: IC156.6 (O), IC156.9 (I0)
unnamed: IC156.10 (I1), IC156.11 (O)
unnamed: IC156.3 (O), IC156.4 (I0), IC156.12 (I0)
unnamed: IC152.8 (O), IC156.1 (I0), IC156.13 (I1)
unnamed: IC152.6 (O), IC152.9 (I0)
unnamed: IC152.10 (I1), IC152.11 (O)
unnamed: IC158.10 (I1), IC158.11 (O)
unnamed: IC158.6 (O), IC158.9 (I0)
unnamed: IC158.8 (O), IC161.1 (I0), IC161.13 (I1)
unnamed: IC161.3 (O), IC161.4 (I0), IC161.12 (I0)
unnamed: IC161.6 (O), IC161.9 (I0)
unnamed: IC161.10 (I1), IC161.11 (O)
unnamed: IC155.3 (O), IC155.4 (I0), IC155.12 (I0)
unnamed: IC151.8 (O), IC155.1 (I0), IC155.13 (I1)
unnamed: IC155.10 (I1), IC155.11 (O)
unnamed: IC155.6 (O), IC155.9 (I0)
unnamed: IC151.10 (I1), IC151.11 (O)
unnamed: IC151.6 (O), IC151.9 (I0)
unnamed: IC157.6 (O), IC157.9 (I0)
unnamed: IC157.10 (I1), IC157.11 (O)
unnamed: IC157.8 (O), IC160.1 (I0), IC160.13 (I1)
unnamed: IC160.3 (O), IC160.4 (I0), IC160.12 (I0)
unnamed: IC160.6 (O), IC160.9 (I0)
unnamed: IC160.10 (I1), IC160.11 (O)
unnamed: IC153.3 (O), IC153.9 (I0)
unnamed: IC153.6 (O), IC153.10 (I1)
unnamed: IC159.3 (O), IC159.5 (I1)
unnamed: IC153.11 (O), IC159.4 (I0)
unnamed: IC154.2 (I1), IC159.11 (O)
unnamed: IC154.1 (I0), IC159.8 (O)
unnamed: IC154.8 (O), IC154.13 (I1)
unnamed: IC154.6 (O), IC154.12 (I0)
P2: IC154.11 (O); also elsewhere on the board
P3: IC154.3 (O); also elsewhere on the board
P4: IC159.6 (O); also elsewhere on the board
P5: IC153.8 (O); also elsewhere on the board
PROD2: IC160.8 (O); also elsewhere on the board
PROD3: IC155.8 (O); also elsewhere on the board
PROD4: IC161.8 (O); also elsewhere on the board
PROD5: IC156.8 (O); also elsewhere on the board
VCC: IC151.14 (VCC), IC152.14 (VCC), IC153.14 (VCC), IC154.14 (VCC), IC155.14 (VCC), IC156.14 (VCC), IC157.14 (VCC), IC158.14 (VCC), IC159.14 (VCC), IC160.14 (VCC), IC161.14 (VCC); also elsewhere on the board
W0: IC151.1 (I0), IC151.13 (I1), IC159.9 (I0), IC159.10 (I1); also elsewhere on the board
W1: IC153.12 (I0), IC153.13 (I1), IC158.1 (I0), IC158.13 (I1); also elsewhere on the board
W2: IC152.1 (I0), IC152.13 (I1), IC153.1 (I0), IC153.2 (I1); also elsewhere on the board
X0: IC151.2 (I1), IC151.5 (I1), IC159.12 (I0), IC159.13 (I1); also elsewhere on the board
Y0: IC154.4 (I0), IC154.5 (I1), IC157.1 (I0), IC157.13 (I1); also elsewhere on the board
Z0: IC158.2 (I1), IC158.5 (I1), IC159.1 (I0), IC159.2 (I1); also elsewhere on the board
Z1: IC152.2 (I1), IC152.5 (I1), IC153.4 (I0), IC153.5 (I1); also elsewhere on the board

Notes on the sheet:
CLA_MULT 5
CLA_MULT 4
CLA_MULT 3
CLA_MULT 2

Schematic: main.sch, sheet 23, CLA_MULT 15, CLU_MULT

Parts:
IC162, IC163, IC164, IC165, IC166, IC167, IC168, IC169, IC170: 74HC00D; SO14

Connections:
C1: IC163.3 (O), IC163.4 (I0); also elsewhere on the board
C2: IC163.8 (O), IC163.12 (I0); also elsewhere on the board
C3: IC166.3 (O), IC166.4 (I0); also elsewhere on the board
C4: IC166.8 (O), IC166.12 (I0); also elsewhere on the board
C5: IC164.3 (O), IC164.4 (I0); also elsewhere on the board
C6: IC164.8 (O), IC164.12 (I0); also elsewhere on the board
C7: IC167.3 (O), IC167.4 (I0); also elsewhere on the board
C8: IC167.8 (O), IC167.12 (I0); also elsewhere on the board
C9: IC168.3 (O), IC168.4 (I0); also elsewhere on the board
C10: IC168.8 (O), IC168.12 (I0); also elsewhere on the board
C11: IC170.3 (O), IC170.4 (I0); also elsewhere on the board
C12: IC170.8 (O), IC170.12 (I0); also elsewhere on the board
C13: IC169.3 (O), IC169.4 (I0); also elsewhere on the board
C14: IC162.6 (O), IC162.9 (I0); also elsewhere on the board
C15: IC162.11 (O), IC165.2 (I1), IC165.5 (I1)
F0: IC164.13 (I1); also elsewhere on the board
G8: IC162.1 (I0), IC162.2 (I1); also elsewhere on the board
GND: IC162.7 (GND), IC163.7 (GND), IC164.7 (GND), IC165.7 (GND), IC166.7 (GND), IC167.7 (GND), IC168.7 (GND), IC169.7 (GND), IC170.7 (GND); also elsewhere on the board
G_N0: IC163.1 (I0), IC163.2 (I1); also elsewhere on the board
G_N2: IC166.2 (I1); also elsewhere on the board
G_N3: IC166.10 (I1); also elsewhere on the board
G_N4: IC164.2 (I1); also elsewhere on the board
G_N5: IC164.10 (I1); also elsewhere on the board
G_N7: IC167.10 (I1); also elsewhere on the board
G_N8: IC168.1 (I0); also elsewhere on the board
G_N9: IC168.10 (I1); also elsewhere on the board
G_N10: IC170.2 (I1); also elsewhere on the board
G_N11: IC170.10 (I1); also elsewhere on the board
G_N12: IC169.2 (I1); also elsewhere on the board
G_N13: IC162.5 (I1); also elsewhere on the board
G_N14: IC162.13 (I1); also elsewhere on the board
unnamed: IC162.3 (O), IC165.1 (I0), IC165.13 (I1)
unnamed: IC165.3 (O), IC165.4 (I0), IC165.12 (I0)
unnamed: IC164.1 (I0), IC166.11 (O)
unnamed: IC165.6 (O), IC165.9 (I0)
unnamed: IC165.10 (I1), IC165.11 (O)
unnamed: IC163.6 (O), IC163.9 (I0), IC163.10 (I1)
unnamed: IC163.11 (O), IC166.1 (I0)
unnamed: IC166.6 (O), IC166.9 (I0)
unnamed: IC164.11 (O), IC167.1 (I0), IC167.2 (I1)
unnamed: IC164.6 (O), IC164.9 (I0)
unnamed: IC167.6 (O), IC167.9 (I0)
unnamed: IC167.11 (O), IC168.2 (I1)
unnamed: IC168.6 (O), IC168.9 (I0)
unnamed: IC168.11 (O), IC170.1 (I0)
unnamed: IC170.6 (O), IC170.9 (I0)
unnamed: IC169.1 (I0), IC170.11 (O)
unnamed: IC162.4 (I0), IC169.6 (O)
unnamed: IC162.8 (O), IC162.12 (I0)
P2: IC163.13 (I1); also elsewhere on the board
P3: IC166.5 (I1); also elsewhere on the board
P4: IC166.13 (I1); also elsewhere on the board
P5: IC164.5 (I1); also elsewhere on the board
P7: IC167.5 (I1); also elsewhere on the board
P8: IC167.13 (I1); also elsewhere on the board
P9: IC168.5 (I1); also elsewhere on the board
P10: IC168.13 (I1); also elsewhere on the board
P11: IC170.5 (I1); also elsewhere on the board
P12: IC170.13 (I1); also elsewhere on the board
P13: IC169.5 (I1); also elsewhere on the board
P14: IC162.10 (I1); also elsewhere on the board
PP0_1: IC163.5 (I1); also elsewhere on the board
PROD15: IC165.8 (O)
VCC: IC162.14 (VCC), IC163.14 (VCC), IC164.14 (VCC), IC165.14 (VCC), IC166.14 (VCC), IC167.14 (VCC), IC168.14 (VCC), IC169.14 (VCC), IC170.14 (VCC); also elsewhere on the board

Notes on the sheet:
CLA FA_1B15
CLU_MULT

Schematic: main.sch, sheet 24, AND, NOT, OR ADDCARD

Parts:
IC171, IC172, IC173, IC174, IC175, IC176, IC177, IC178, IC179, IC180, IC181, IC182: 74HC00D; SO14

Connections:
A0: IC171.1 (I0), IC175.1 (I0), IC175.2 (I1), IC177.1 (I0), IC177.2 (I1); also elsewhere on the board
A1: IC171.9 (I0), IC175.4 (I0), IC175.5 (I1), IC177.9 (I0), IC177.10 (I1); also elsewhere on the board
A2: IC172.1 (I0), IC175.9 (I0), IC175.10 (I1), IC178.1 (I0), IC178.2 (I1); also elsewhere on the board
A3: IC172.9 (I0), IC175.12 (I0), IC175.13 (I1), IC178.9 (I0), IC178.10 (I1); also elsewhere on the board
A4: IC173.1 (I0), IC176.1 (I0), IC176.2 (I1), IC179.1 (I0), IC179.2 (I1); also elsewhere on the board
A5: IC173.9 (I0), IC176.4 (I0), IC176.5 (I1), IC179.9 (I0), IC179.10 (I1); also elsewhere on the board
A6: IC174.1 (I0), IC176.9 (I0), IC176.10 (I1), IC180.1 (I0), IC180.2 (I1); also elsewhere on the board
A7: IC174.9 (I0), IC176.12 (I0), IC176.13 (I1), IC180.9 (I0), IC180.10 (I1); also elsewhere on the board
AND0: IC171.6 (O); also elsewhere on the board
AND1: IC171.11 (O); also elsewhere on the board
AND2: IC172.6 (O); also elsewhere on the board
AND3: IC172.11 (O); also elsewhere on the board
AND4: IC173.6 (O); also elsewhere on the board
AND5: IC173.11 (O); also elsewhere on the board
AND6: IC174.6 (O); also elsewhere on the board
AND7: IC174.11 (O); also elsewhere on the board
B0: IC171.2 (I1), IC177.4 (I0), IC177.5 (I1); also elsewhere on the board
B1: IC171.10 (I1), IC177.12 (I0), IC177.13 (I1); also elsewhere on the board
B2: IC172.2 (I1), IC178.4 (I0), IC178.5 (I1); also elsewhere on the board
B3: IC172.10 (I1), IC178.12 (I0), IC178.13 (I1); also elsewhere on the board
B4: IC173.2 (I1), IC179.4 (I0), IC179.5 (I1); also elsewhere on the board
B5: IC173.10 (I1), IC179.12 (I0), IC179.13 (I1); also elsewhere on the board
B6: IC174.2 (I1), IC180.4 (I0), IC180.5 (I1); also elsewhere on the board
B7: IC174.10 (I1), IC180.12 (I0), IC180.13 (I1); also elsewhere on the board
GND: IC171.7 (GND), IC172.7 (GND), IC173.7 (GND), IC174.7 (GND), IC175.7 (GND), IC176.7 (GND), IC177.7 (GND), IC178.7 (GND), IC179.7 (GND), IC180.7 (GND), IC181.7 (GND), IC182.7 (GND); also elsewhere on the board
unnamed: IC171.3 (O), IC171.4 (I0), IC171.5 (I1)
unnamed: IC171.8 (O), IC171.12 (I0), IC171.13 (I1)
unnamed: IC172.3 (O), IC172.4 (I0), IC172.5 (I1)
unnamed: IC172.8 (O), IC172.12 (I0), IC172.13 (I1)
unnamed: IC173.3 (O), IC173.4 (I0), IC173.5 (I1)
unnamed: IC173.8 (O), IC173.12 (I0), IC173.13 (I1)
unnamed: IC174.3 (O), IC174.4 (I0), IC174.5 (I1)
unnamed: IC174.8 (O), IC174.12 (I0), IC174.13 (I1)
unnamed: IC177.3 (O), IC181.1 (I0)
unnamed: IC177.6 (O), IC181.2 (I1)
unnamed: IC177.8 (O), IC181.4 (I0)
unnamed: IC177.11 (O), IC181.5 (I1)
unnamed: IC178.3 (O), IC181.9 (I0)
unnamed: IC178.6 (O), IC181.10 (I1)
unnamed: IC178.8 (O), IC181.12 (I0)
unnamed: IC178.11 (O), IC181.13 (I1)
unnamed: IC179.3 (O), IC182.1 (I0)
unnamed: IC179.6 (O), IC182.2 (I1)
unnamed: IC179.8 (O), IC182.4 (I0)
unnamed: IC179.11 (O), IC182.5 (I1)
unnamed: IC180.3 (O), IC182.9 (I0)
unnamed: IC180.6 (O), IC182.10 (I1)
unnamed: IC180.8 (O), IC182.12 (I0)
unnamed: IC180.11 (O), IC182.13 (I1)
NOT0: IC175.3 (O); also elsewhere on the board
NOT1: IC175.6 (O); also elsewhere on the board
NOT2: IC175.8 (O); also elsewhere on the board
NOT3: IC175.11 (O); also elsewhere on the board
NOT4: IC176.3 (O); also elsewhere on the board
NOT5: IC176.6 (O); also elsewhere on the board
NOT6: IC176.8 (O); also elsewhere on the board
NOT7: IC176.11 (O); also elsewhere on the board
OR0: IC181.3 (O); also elsewhere on the board
OR1: IC181.6 (O); also elsewhere on the board
OR2: IC181.8 (O); also elsewhere on the board
OR3: IC181.11 (O); also elsewhere on the board
OR4: IC182.3 (O); also elsewhere on the board
OR5: IC182.6 (O); also elsewhere on the board
OR6: IC182.8 (O); also elsewhere on the board
OR7: IC182.11 (O); also elsewhere on the board
VCC: IC171.14 (VCC), IC172.14 (VCC), IC173.14 (VCC), IC174.14 (VCC), IC175.14 (VCC), IC176.14 (VCC), IC177.14 (VCC), IC178.14 (VCC), IC179.14 (VCC), IC180.14 (VCC), IC181.14 (VCC), IC182.14 (VCC); also elsewhere on the board

Notes on the sheet:
AND
NOT
