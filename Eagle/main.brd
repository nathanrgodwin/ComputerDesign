# Repository nathanrgodwin/ComputerDesign (continued)

## EAGLE design Eagle/main.brd (continued)

Schematic: main.sch, sheet 46

Parts:
IC472, IC473, IC474, IC487, IC488, IC489, IC490, IC491, IC492, IC493, IC494, IC495, IC496, IC497, IC498, IC499, IC500, IC501, IC502: 74HC00D; SO14

Connections:
ADDSUB_SEL_N: IC487.2 (I1); also elsewhere on the board
ADD_SEL: IC487.3 (O), IC487.4 (I0), IC487.5 (I1)
ADD_SEL_N: IC487.6 (O), IC488.2 (I1); also elsewhere on the board
AND_SEL_N: IC487.9 (I0); also elsewhere on the board
CMD1: IC502.5 (I1); also elsewhere on the board
CMD6: IC474.13 (I1); also elsewhere on the board
CMDN0: IC487.10 (I1); also elsewhere on the board
CMDN2: IC491.2 (I1); also elsewhere on the board
CMDN7: IC488.5 (I1); also elsewhere on the board
CSELN: IC487.1 (I0); also elsewhere on the board
DATABUS0: IC491.4 (I0), IC491.5 (I1)
DATABUS0_: IC491.6 (O)
DATABUS1: IC491.9 (I0), IC491.10 (I1)
DATABUS1_: IC491.8 (O)
DATABUS2: IC491.12 (I0), IC491.13 (I1)
DATABUS2_: IC491.11 (O)
DATABUS3: IC492.1 (I0), IC492.2 (I1)
DATABUS3_: IC492.3 (O)
EQN: IC472.1 (I0), IC501.3 (O)
GEQN: IC498.11 (O), IC501.13 (I1)
GND: IC472.7 (GND), IC473.7 (GND), IC474.7 (GND), IC487.7 (GND), IC488.7 (GND), IC489.7 (GND), IC490.7 (GND), IC491.7 (GND), IC492.7 (GND), IC493.7 (GND), IC494.7 (GND), IC495.7 (GND), IC496.7 (GND), IC497.7 (GND), IC498.7 (GND), IC499.7 (GND), IC500.7 (GND), IC501.7 (GND), IC502.7 (GND); also elsewhere on the board
GREATERN: IC498.8 (O), IC501.12 (I0)
JAB_EN: IC502.8 (O); also elsewhere on the board
JMP_EN: IC502.3 (O); also elsewhere on the board
JMP_EN_CTRL: IC474.3 (O), IC474.4 (I0)
JMP_OPDAT: IC474.8 (O), IC474.12 (I0), IC502.4 (I0)
LEQN: IC498.6 (O), IC501.10 (I1)
LESSN: IC498.3 (O), IC501.9 (I0)
unnamed: IC487.11 (O), IC488.12 (I0), IC488.13 (I1)
unnamed: IC487.8 (O), IC488.9 (I0), IC488.10 (I1)
unnamed: IC488.6 (O), IC489.4 (I0), IC489.5 (I1)
unnamed: IC489.6 (O), IC489.13 (I1)
unnamed: IC488.3 (O), IC489.1 (I0), IC489.2 (I1)
unnamed: IC489.3 (O), IC489.12 (I0)
unnamed: IC488.11 (O), IC489.10 (I1)
unnamed: IC488.8 (O), IC489.9 (I0)
unnamed: IC489.8 (O), IC490.1 (I0), IC490.2 (I1)
unnamed: IC489.11 (O), IC490.4 (I0), IC490.5 (I1)
unnamed: IC490.3 (O), IC490.9 (I0)
unnamed: IC490.6 (O), IC490.10 (I1)
unnamed: IC490.8 (O), IC490.12 (I0), IC490.13 (I1)
unnamed: IC490.11 (O), IC491.1 (I0)
unnamed: IC493.8 (O), IC493.12 (I0)
unnamed: IC499.6 (O), IC501.1 (I0)
unnamed: IC499.11 (O), IC501.2 (I1)
unnamed: IC493.6 (O), IC493.9 (I0), IC493.10 (I1)
unnamed: IC494.3 (O), IC494.4 (I0), IC494.5 (I1)
unnamed: IC494.8 (O), IC494.12 (I0), IC494.13 (I1)
unnamed: IC494.11 (O), IC498.2 (I1)
unnamed: IC494.6 (O), IC498.1 (I0)
unnamed: IC495.6 (O), IC498.4 (I0)
unnamed: IC495.11 (O), IC498.5 (I1)
unnamed: IC495.8 (O), IC495.12 (I0), IC495.13 (I1)
unnamed: IC495.3 (O), IC495.4 (I0), IC495.5 (I1)
unnamed: IC496.3 (O), IC496.4 (I0), IC496.5 (I1)
unnamed: IC496.8 (O), IC496.12 (I0), IC496.13 (I1)
unnamed: IC496.6 (O), IC498.9 (I0)
unnamed: IC496.11 (O), IC498.10 (I1)
unnamed: IC497.6 (O), IC498.12 (I0)
unnamed: IC497.11 (O), IC498.13 (I1)
unnamed: IC497.8 (O), IC497.12 (I0), IC497.13 (I1)
unnamed: IC497.3 (O), IC497.4 (I0), IC497.5 (I1)
unnamed: IC500.6 (O), IC501.4 (I0)
unnamed: IC500.11 (O), IC501.5 (I1)
unnamed: IC500.8 (O), IC500.12 (I0), IC500.13 (I1)
unnamed: IC500.3 (O), IC500.4 (I0), IC500.5 (I1)
unnamed: IC499.8 (O), IC499.12 (I0), IC499.13 (I1)
unnamed: IC499.3 (O), IC499.4 (I0), IC499.5 (I1)
unnamed: IC472.4 (I0), IC472.5 (I1), IC501.8 (O)
unnamed: IC472.9 (I0), IC472.10 (I1), IC501.11 (O)
unnamed: IC472.6 (O), IC473.1 (I0)
unnamed: IC472.3 (O), IC472.12 (I0), IC472.13 (I1)
unnamed: IC472.11 (O), IC473.4 (I0)
unnamed: IC472.8 (O), IC473.2 (I1)
unnamed: IC473.3 (O), IC473.9 (I0), IC473.10 (I1)
unnamed: IC473.8 (O), IC474.1 (I0)
unnamed: IC473.11 (O), IC474.2 (I1)
unnamed: IC473.6 (O), IC473.12 (I0), IC473.13 (I1)
unnamed: IC474.6 (O), IC474.9 (I0), IC474.10 (I1)
unnamed: IC502.6 (O), IC502.9 (I0), IC502.10 (I1)
unnamed: IC474.11 (O), IC502.1 (I0), IC502.2 (I1)
NEQN: IC472.2 (I1), IC501.6 (O)
NOT_SEL_N: IC487.12 (I0); also elsewhere on the board
OP0: IC494.1 (I0), IC496.1 (I0), IC499.1 (I0); also elsewhere on the board
OP1: IC495.2 (I1), IC496.2 (I1), IC500.2 (I1); also elsewhere on the board
OP2: IC497.9 (I0), IC499.9 (I0), IC500.9 (I0); also elsewhere on the board
OPDATASELECTOR1: IC474.5 (I1); also elsewhere on the board
OPN0: IC493.4 (I0), IC495.1 (I0), IC497.1 (I0), IC500.1 (I0); also elsewhere on the board
OPN1: IC493.5 (I1), IC494.2 (I1), IC497.2 (I1), IC499.2 (I1); also elsewhere on the board
OPN2: IC493.13 (I1), IC494.9 (I0), IC495.9 (I0), IC496.9 (I0); also elsewhere on the board
OR_SEL_N: IC487.13 (I1); also elsewhere on the board
REG_EN: IC491.3 (O); also elsewhere on the board
RSEL15: IC502.11 (O); also elsewhere on the board
RSELN15: IC502.12 (I0), IC502.13 (I1); also elsewhere on the board
S: IC492.9 (I0), IC492.10 (I1), IC496.10 (I1)
SHIFT_SEL_N: IC488.4 (I0); also elsewhere on the board
SOZ: IC492.11 (O), IC493.1 (I0), IC493.2 (I1), IC497.10 (I1)
SOZN: IC493.3 (O), IC494.10 (I1)
S_N: IC492.8 (O), IC492.13 (I1), IC495.10 (I1)
UNCONN: IC473.5 (I1), IC493.11 (O)
VCC: IC472.14 (VCC), IC473.14 (VCC), IC474.14 (VCC), IC487.14 (VCC), IC488.14 (VCC), IC489.14 (VCC), IC490.14 (VCC), IC491.14 (VCC), IC492.14 (VCC), IC493.14 (VCC), IC494.14 (VCC), IC495.14 (VCC), IC496.14 (VCC), IC497.14 (VCC), IC498.14 (VCC), IC499.14 (VCC), IC500.14 (VCC), IC501.14 (VCC), IC502.14 (VCC); also elsewhere on the board
XOR_SEL_N: IC488.1 (I0); also elsewhere on the board
Z: IC492.4 (I0), IC492.5 (I1), IC499.10 (I1); also elsewhere on the board
Z_N: IC492.6 (O), IC492.12 (I0), IC500.10 (I1)

Schematic: main.sch, sheet 47

Parts:
IC503, IC504, IC505, IC506, IC507, IC508, IC509, IC510, IC511, IC512: 74HC125D; SO14

Connections:
CMDN2: IC509.1 (OE), IC509.4 (OE), IC509.10 (OE), IC509.13 (OE), IC510.1 (OE), IC510.4 (OE), IC510.10 (OE), IC510.13 (OE); also elsewhere on the board
CMDN3: IC507.1 (OE), IC507.4 (OE), IC507.10 (OE), IC507.13 (OE), IC508.1 (OE), IC508.4 (OE), IC508.10 (OE), IC508.13 (OE); also elsewhere on the board
GND: IC503.7 (GND), IC504.7 (GND), IC505.7 (GND), IC506.7 (GND), IC507.7 (GND), IC508.7 (GND), IC509.7 (GND), IC510.7 (GND), IC511.7 (GND), IC512.7 (GND); also elsewhere on the board
LOADORSTORE: IC503.1 (OE), IC503.4 (OE), IC503.10 (OE), IC503.13 (OE), IC504.1 (OE), IC504.4 (OE), IC504.10 (OE), IC504.13 (OE), IC511.1 (OE), IC511.4 (OE), IC511.10 (OE), IC511.13 (OE), IC512.1 (OE), IC512.4 (OE), IC512.10 (OE), IC512.13 (OE)
LOADORSTORE_: IC505.1 (OE), IC505.4 (OE), IC505.10 (OE), IC505.13 (OE), IC506.1 (OE), IC506.4 (OE), IC506.10 (OE), IC506.13 (OE)
MEM_ADDR0: IC508.11 (O), IC510.11 (O), IC512.11 (O)
MEM_ADDR1: IC508.8 (O), IC510.8 (O), IC512.8 (O)
MEM_ADDR2: IC508.6 (O), IC510.6 (O), IC512.6 (O)
MEM_ADDR3: IC508.3 (O), IC510.3 (O), IC512.3 (O)
MEM_ADDR4: IC507.11 (O), IC509.11 (O), IC511.11 (O)
MEM_ADDR5: IC507.8 (O), IC509.8 (O), IC511.8 (O)
MEM_ADDR6: IC507.6 (O), IC509.6 (O), IC511.6 (O)
MEM_ADDR7: IC507.3 (O), IC509.3 (O), IC511.3 (O)
MEM_ADDR8: IC504.11 (O), IC506.11 (O)
MEM_ADDR9: IC504.8 (O), IC506.8 (O)
MEM_ADDR10: IC504.6 (O), IC506.6 (O)
MEM_ADDR11: IC504.3 (O), IC506.3 (O)
MEM_ADDR12: IC503.11 (O), IC505.11 (O)
MEM_ADDR13: IC503.8 (O), IC505.8 (O)
MEM_ADDR14: IC503.6 (O), IC505.6 (O)
MEM_ADDR15: IC503.3 (O), IC505.3 (O)
OP0: IC510.12 (I); also elsewhere on the board
OP1: IC510.9 (I); also elsewhere on the board
OP2: IC510.5 (I); also elsewhere on the board
OP3: IC510.2 (I); also elsewhere on the board
OP4: IC508.12 (I), IC509.12 (I); also elsewhere on the board
OP5: IC508.9 (I), IC509.9 (I); also elsewhere on the board
OP6: IC508.5 (I), IC509.5 (I); also elsewhere on the board
OP7: IC508.2 (I), IC509.2 (I); also elsewhere on the board
OP8: IC507.12 (I); also elsewhere on the board
OP9: IC507.9 (I); also elsewhere on the board
OP10: IC507.5 (I); also elsewhere on the board
OP11: IC507.2 (I); also elsewhere on the board
PC_REG0: IC512.12 (I); also elsewhere on the board
PC_REG1: IC512.9 (I); also elsewhere on the board
PC_REG2: IC512.5 (I); also elsewhere on the board
PC_REG3: IC512.2 (I); also elsewhere on the board
PC_REG4: IC511.12 (I); also elsewhere on the board
PC_REG5: IC511.9 (I); also elsewhere on the board
PC_REG6: IC511.5 (I); also elsewhere on the board
PC_REG7: IC511.2 (I); also elsewhere on the board
PC_REG8: IC504.12 (I); also elsewhere on the board
PC_REG9: IC504.9 (I); also elsewhere on the board
PC_REG10: IC504.5 (I); also elsewhere on the board
PC_REG11: IC504.2 (I); also elsewhere on the board
PC_REG12: IC503.12 (I); also elsewhere on the board
PC_REG13: IC503.9 (I); also elsewhere on the board
PC_REG14: IC503.5 (I); also elsewhere on the board
PC_REG15: IC503.2 (I); also elsewhere on the board
REG14_0: IC506.12 (I); also elsewhere on the board
REG14_1: IC506.9 (I); also elsewhere on the board
REG14_2: IC506.5 (I); also elsewhere on the board
REG14_3: IC506.2 (I); also elsewhere on the board
REG14_4: IC505.12 (I); also elsewhere on the board
REG14_5: IC505.9 (I); also elsewhere on the board
REG14_6: IC505.5 (I); also elsewhere on the board
REG14_7: IC505.2 (I); also elsewhere on the board
VCC: IC503.14 (VCC), IC504.14 (VCC), IC505.14 (VCC), IC506.14 (VCC), IC507.14 (VCC), IC508.14 (VCC), IC509.14 (VCC), IC510.14 (VCC), IC511.14 (VCC), IC512.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 48

Parts:
IC513, IC514, IC515, IC516, IC517, IC518, IC519, IC520: 74HC00D; SO14

Connections:
GND: IC513.7 (GND), IC514.7 (GND), IC515.7 (GND), IC516.7 (GND), IC517.7 (GND), IC518.7 (GND), IC519.7 (GND), IC520.7 (GND); also elsewhere on the board
unnamed: IC514.3 (O), IC514.4 (I0)
unnamed: IC514.11 (O), IC515.1 (I0)
unnamed: IC515.8 (O), IC515.12 (I0)
unnamed: IC516.6 (O), IC516.9 (I0)
unnamed: IC517.3 (O), IC517.4 (I0)
unnamed: IC517.11 (O), IC518.1 (I0)
unnamed: IC518.8 (O), IC518.12 (I0)
unnamed: IC519.6 (O), IC519.9 (I0)
unnamed: IC513.11 (O), IC514.1 (I0), IC514.2 (I1)
unnamed: IC514.8 (O), IC514.12 (I0), IC514.13 (I1)
unnamed: IC515.6 (O), IC515.9 (I0), IC515.10 (I1)
unnamed: IC516.3 (O), IC516.4 (I0), IC516.5 (I1)
unnamed: IC516.11 (O), IC517.1 (I0), IC517.2 (I1)
unnamed: IC517.8 (O), IC517.12 (I0), IC517.13 (I1)
unnamed: IC518.6 (O), IC518.9 (I0), IC518.10 (I1)
unnamed: IC519.3 (O), IC519.4 (I0), IC519.5 (I1)
PRE_CTR_REG0_: IC519.11 (O)
REG15_0: IC519.12 (I0); also elsewhere on the board
REG15_5: IC513.9 (I0), IC513.10 (I1), IC515.2 (I1), IC516.10 (I1), IC518.2 (I1), IC519.10 (I1); also elsewhere on the board
REG15_6: IC513.4 (I0), IC513.5 (I1), IC515.5 (I1), IC516.2 (I1), IC518.5 (I1), IC519.2 (I1); also elsewhere on the board
REG15_7: IC513.1 (I0), IC513.2 (I1), IC516.12 (I0), IC517.9 (I0), IC518.4 (I0), IC519.1 (I0); also elsewhere on the board
REGN15_5: IC513.8 (O), IC514.5 (I1), IC515.13 (I1), IC517.5 (I1), IC518.13 (I1)
REGN15_6: IC513.6 (O), IC513.13 (I1), IC514.10 (I1), IC516.13 (I1), IC517.10 (I1)
REGN15_7: IC513.3 (O), IC513.12 (I0), IC514.9 (I0), IC515.4 (I0), IC516.1 (I0)
RSEL15: IC519.13 (I1); also elsewhere on the board
VCC: IC513.14 (VCC), IC514.14 (VCC), IC515.14 (VCC), IC516.14 (VCC), IC517.14 (VCC), IC518.14 (VCC), IC519.14 (VCC), IC520.14 (VCC); also elsewhere on the board

Board: 4 copper layers, 531 parts (0 on the bottom side), 1854 nets, no tracks yet.
