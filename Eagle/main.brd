# Repository nathanrgodwin/ComputerDesign (continued)

## EAGLE design Eagle/main.brd (continued)

Schematic: main.sch, sheet 25, XOR

Parts:
IC183, IC184, IC185, IC186, IC187, IC188, IC189, IC190: 74HC00D; SO14

Connections:
A0: IC183.1 (I0), IC183.13 (I1); also elsewhere on the board
A1: IC184.1 (I0), IC184.13 (I1); also elsewhere on the board
A2: IC185.1 (I0), IC185.13 (I1); also elsewhere on the board
A3: IC186.1 (I0), IC186.13 (I1); also elsewhere on the board
A4: IC187.1 (I0), IC187.13 (I1); also elsewhere on the board
A5: IC188.1 (I0), IC188.13 (I1); also elsewhere on the board
A6: IC189.1 (I0), IC189.13 (I1); also elsewhere on the board
A7: IC190.1 (I0), IC190.13 (I1); also elsewhere on the board
B0: IC183.2 (I1), IC183.5 (I1); also elsewhere on the board
B1: IC184.2 (I1), IC184.5 (I1); also elsewhere on the board
B2: IC185.2 (I1), IC185.5 (I1); also elsewhere on the board
B3: IC186.2 (I1), IC186.5 (I1); also elsewhere on the board
B4: IC187.2 (I1), IC187.5 (I1); also elsewhere on the board
B5: IC188.2 (I1), IC188.5 (I1); also elsewhere on the board
B6: IC189.2 (I1), IC189.5 (I1); also elsewhere on the board
B7: IC190.2 (I1), IC190.5 (I1); also elsewhere on the board
GND: IC183.7 (GND), IC184.7 (GND), IC185.7 (GND), IC186.7 (GND), IC187.7 (GND), IC188.7 (GND), IC189.7 (GND), IC190.7 (GND); also elsewhere on the board
unnamed: IC186.6 (O), IC186.9 (I0)
unnamed: IC186.10 (I1), IC186.11 (O)
unnamed: IC189.3 (O), IC189.4 (I0), IC189.12 (I0)
unnamed: IC189.10 (I1), IC189.11 (O)
unnamed: IC189.6 (O), IC189.9 (I0)
unnamed: IC185.6 (O), IC185.9 (I0)
unnamed: IC185.10 (I1), IC185.11 (O)
unnamed: IC190.3 (O), IC190.4 (I0), IC190.12 (I0)
unnamed: IC190.6 (O), IC190.9 (I0)
unnamed: IC190.10 (I1), IC190.11 (O)
unnamed: IC188.10 (I1), IC188.11 (O)
unnamed: IC188.6 (O), IC188.9 (I0)
unnamed: IC188.3 (O), IC188.4 (I0), IC188.12 (I0)
unnamed: IC187.3 (O), IC187.4 (I0), IC187.12 (I0)
unnamed: IC187.6 (O), IC187.9 (I0)
unnamed: IC187.10 (I1), IC187.11 (O)
unnamed: IC186.3 (O), IC186.4 (I0), IC186.12 (I0)
unnamed: IC185.3 (O), IC185.4 (I0), IC185.12 (I0)
unnamed: IC184.3 (O), IC184.4 (I0), IC184.12 (I0)
unnamed: IC184.6 (O), IC184.9 (I0)
unnamed: IC184.10 (I1), IC184.11 (O)
unnamed: IC183.6 (O), IC183.9 (I0)
unnamed: IC183.10 (I1), IC183.11 (O)
unnamed: IC183.3 (O), IC183.4 (I0), IC183.12 (I0)
VCC: IC183.14 (VCC), IC184.14 (VCC), IC185.14 (VCC), IC186.14 (VCC), IC187.14 (VCC), IC188.14 (VCC), IC189.14 (VCC), IC190.14 (VCC); also elsewhere on the board
XOR0: IC183.8 (O); also elsewhere on the board
XOR1: IC184.8 (O); also elsewhere on the board
XOR2: IC185.8 (O); also elsewhere on the board
XOR3: IC186.8 (O); also elsewhere on the board
XOR4: IC187.8 (O); also elsewhere on the board
XOR5: IC188.8 (O); also elsewhere on the board
XOR6: IC189.8 (O); also elsewhere on the board
XOR7: IC190.8 (O); also elsewhere on the board

Notes on the sheet:
XOR

Schematic: main.sch, sheet 26, ADDSUB 0-3

Parts:
IC191, IC192, IC193, IC194, IC195, IC196, IC197, IC198, IC199, IC200, IC201, IC202, IC203, IC204, IC205, IC206: 74HC00D; SO14

Connections:
A0: IC195.2 (I1), IC195.5 (I1), IC198.4 (I0), IC198.5 (I1); also elsewhere on the board
A1: IC196.2 (I1), IC196.5 (I1), IC198.12 (I0), IC198.13 (I1); also elsewhere on the board
A2: IC197.2 (I1), IC197.5 (I1), IC200.9 (I0), IC200.10 (I1); also elsewhere on the board
A3: IC203.4 (I0), IC203.5 (I1), IC205.2 (I1), IC205.5 (I1); also elsewhere on the board
ADD_C0: IC192.11 (O), IC199.2 (I1), IC199.5 (I1); also elsewhere on the board
ADD_G_N0: IC195.3 (O), IC195.4 (I0), IC195.12 (I0); also elsewhere on the board
ADD_G_N1: IC196.3 (O), IC196.4 (I0), IC196.12 (I0); also elsewhere on the board
ADD_G_N2: IC197.3 (O), IC197.4 (I0), IC197.12 (I0); also elsewhere on the board
ADD_G_N3: IC205.3 (O), IC205.4 (I0), IC205.12 (I0); also elsewhere on the board
ADD_P0: IC198.8 (O); also elsewhere on the board
ADD_P1: IC200.6 (O); also elsewhere on the board
ADD_P2: IC203.3 (O); also elsewhere on the board
ADD_P3: IC203.11 (O); also elsewhere on the board
B0: IC191.2 (I1), IC191.5 (I1); also elsewhere on the board
B1: IC193.2 (I1), IC193.5 (I1); also elsewhere on the board
B2: IC194.2 (I1), IC194.5 (I1); also elsewhere on the board
B3: IC204.2 (I1), IC204.5 (I1); also elsewhere on the board
CIN: IC192.9 (I0)
CIN1: IC201.2 (I1), IC201.5 (I1); also elsewhere on the board
CIN2: IC202.2 (I1), IC202.5 (I1); also elsewhere on the board
CIN3: IC206.2 (I1), IC206.5 (I1); also elsewhere on the board
CSEL: IC192.1 (I0), IC192.2 (I1), IC192.10 (I1); also elsewhere on the board
GND: IC191.7 (GND), IC192.7 (GND), IC193.7 (GND), IC194.7 (GND), IC195.7 (GND), IC196.7 (GND), IC197.7 (GND), IC198.7 (GND), IC199.7 (GND), IC200.7 (GND), IC201.7 (GND), IC202.7 (GND), IC203.7 (GND), IC204.7 (GND), IC205.7 (GND), IC206.7 (GND); also elsewhere on the board
unnamed: IC191.6 (O), IC191.9 (I0)
unnamed: IC191.10 (I1), IC191.11 (O)
unnamed: IC191.3 (O), IC191.4 (I0), IC191.12 (I0)
unnamed: IC195.6 (O), IC195.9 (I0)
unnamed: IC195.10 (I1), IC195.11 (O)
unnamed: IC199.10 (I1), IC199.11 (O)
unnamed: IC199.6 (O), IC199.9 (I0)
unnamed: IC199.3 (O), IC199.4 (I0), IC199.12 (I0)
unnamed: IC195.8 (O), IC199.1 (I0), IC199.13 (I1)
unnamed: IC193.6 (O), IC193.9 (I0)
unnamed: IC193.10 (I1), IC193.11 (O)
unnamed: IC193.3 (O), IC193.4 (I0), IC193.12 (I0)
unnamed: IC196.6 (O), IC196.9 (I0)
unnamed: IC196.10 (I1), IC196.11 (O)
unnamed: IC201.10 (I1), IC201.11 (O)
unnamed: IC201.6 (O), IC201.9 (I0)
unnamed: IC201.3 (O), IC201.4 (I0), IC201.12 (I0)
unnamed: IC196.8 (O), IC201.1 (I0), IC201.13 (I1)
unnamed: IC194.6 (O), IC194.9 (I0)
unnamed: IC194.10 (I1), IC194.11 (O)
unnamed: IC194.3 (O), IC194.4 (I0), IC194.12 (I0)
unnamed: IC197.6 (O), IC197.9 (I0)
unnamed: IC197.10 (I1), IC197.11 (O)
unnamed: IC202.10 (I1), IC202.11 (O)
unnamed: IC202.6 (O), IC202.9 (I0)
unnamed: IC202.3 (O), IC202.4 (I0), IC202.12 (I0)
unnamed: IC197.8 (O), IC202.1 (I0), IC202.13 (I1)
unnamed: IC204.6 (O), IC204.9 (I0)
unnamed: IC204.10 (I1), IC204.11 (O)
unnamed: IC204.3 (O), IC204.4 (I0), IC204.12 (I0)
unnamed: IC203.9 (I0), IC203.10 (I1), IC204.8 (O), IC205.1 (I0), IC205.13 (I1)
unnamed: IC205.6 (O), IC205.9 (I0)
unnamed: IC205.10 (I1), IC205.11 (O)
unnamed: IC206.10 (I1), IC206.11 (O)
unnamed: IC206.6 (O), IC206.9 (I0)
unnamed: IC206.3 (O), IC206.4 (I0), IC206.12 (I0)
unnamed: IC205.8 (O), IC206.1 (I0), IC206.13 (I1)
unnamed: IC192.3 (O), IC192.4 (I0)
unnamed: IC192.8 (O), IC192.12 (I0)
unnamed: IC192.6 (O), IC192.13 (I1)
unnamed: IC191.8 (O), IC195.1 (I0), IC195.13 (I1), IC198.1 (I0), IC198.2 (I1)
unnamed: IC198.6 (O), IC198.10 (I1)
unnamed: IC198.3 (O), IC198.9 (I0)
unnamed: IC193.8 (O), IC196.1 (I0), IC196.13 (I1), IC200.1 (I0), IC200.2 (I1)
unnamed: IC198.11 (O), IC200.5 (I1)
unnamed: IC200.3 (O), IC200.4 (I0)
unnamed: IC200.11 (O), IC203.1 (I0)
unnamed: IC200.8 (O), IC203.2 (I1)
unnamed: IC194.8 (O), IC197.1 (I0), IC197.13 (I1), IC200.12 (I0), IC200.13 (I1)
unnamed: IC203.6 (O), IC203.13 (I1)
unnamed: IC203.8 (O), IC203.12 (I0)
SUB_SEL: IC191.1 (I0), IC191.13 (I1), IC192.5 (I1), IC193.1 (I0), IC193.13 (I1), IC194.1 (I0), IC194.13 (I1), IC204.1 (I0), IC204.13 (I1); also elsewhere on the board
SUM0: IC199.8 (O); also elsewhere on the board
SUM1: IC201.8 (O); also elsewhere on the board
SUM2: IC202.8 (O); also elsewhere on the board
SUM3: IC206.8 (O); also elsewhere on the board
VCC: IC191.14 (VCC), IC192.14 (VCC), IC193.14 (VCC), IC194.14 (VCC), IC195.14 (VCC), IC196.14 (VCC), IC197.14 (VCC), IC198.14 (VCC), IC199.14 (VCC), IC200.14 (VCC), IC201.14 (VCC), IC202.14 (VCC), IC203.14 (VCC), IC204.14 (VCC), IC205.14 (VCC), IC206.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 27, ADDSUB 4-7

Parts:
IC207, IC208, IC209, IC210, IC211, IC212, IC213, IC214, IC215, IC216, IC217, IC218, IC219, IC220, IC221: 74HC00D; SO14

Connections:
A4: IC210.2 (I1), IC210.5 (I1), IC213.4 (I0), IC213.5 (I1); also elsewhere on the board
A5: IC211.2 (I1), IC211.5 (I1), IC213.12 (I0), IC213.13 (I1); also elsewhere on the board
A6: IC212.2 (I1), IC212.5 (I1), IC215.9 (I0), IC215.10 (I1); also elsewhere on the board
A7: IC218.4 (I0), IC218.5 (I1), IC220.2 (I1), IC220.5 (I1); also elsewhere on the board
ADD_G_N4: IC210.3 (O), IC210.4 (I0), IC210.12 (I0); also elsewhere on the board
ADD_G_N5: IC211.3 (O), IC211.4 (I0), IC211.12 (I0); also elsewhere on the board
ADD_G_N6: IC212.3 (O), IC212.4 (I0), IC212.12 (I0); also elsewhere on the board
ADD_G_N7: IC220.3 (O), IC220.4 (I0), IC220.12 (I0); also elsewhere on the board
ADD_P4: IC213.8 (O); also elsewhere on the board
ADD_P5: IC215.6 (O); also elsewhere on the board
ADD_P6: IC218.3 (O); also elsewhere on the board
ADD_P7: IC218.11 (O); also elsewhere on the board
B4: IC207.2 (I1), IC207.5 (I1); also elsewhere on the board
B5: IC208.2 (I1), IC208.5 (I1); also elsewhere on the board
B6: IC209.2 (I1), IC209.5 (I1); also elsewhere on the board
B7: IC219.2 (I1), IC219.5 (I1); also elsewhere on the board
CIN4: IC214.2 (I1), IC214.5 (I1); also elsewhere on the board
CIN5: IC216.2 (I1), IC216.5 (I1); also elsewhere on the board
CIN6: IC217.2 (I1), IC217.5 (I1); also elsewhere on the board
CIN7: IC221.2 (I1), IC221.5 (I1); also elsewhere on the board
GND: IC207.7 (GND), IC208.7 (GND), IC209.7 (GND), IC210.7 (GND), IC211.7 (GND), IC212.7 (GND), IC213.7 (GND), IC214.7 (GND), IC215.7 (GND), IC216.7 (GND), IC217.7 (GND), IC218.7 (GND), IC219.7 (GND), IC220.7 (GND), IC221.7 (GND); also elsewhere on the board
unnamed: IC207.6 (O), IC207.9 (I0)
unnamed: IC207.10 (I1), IC207.11 (O)
unnamed: IC207.3 (O), IC207.4 (I0), IC207.12 (I0)
unnamed: IC210.6 (O), IC210.9 (I0)
unnamed: IC210.10 (I1), IC210.11 (O)
unnamed: IC214.10 (I1), IC214.11 (O)
unnamed: IC214.6 (O), IC214.9 (I0)
unnamed: IC214.3 (O), IC214.4 (I0), IC214.12 (I0)
unnamed: IC210.8 (O), IC214.1 (I0), IC214.13 (I1)
unnamed: IC208.6 (O), IC208.9 (I0)
unnamed: IC208.10 (I1), IC208.11 (O)
unnamed: IC208.3 (O), IC208.4 (I0), IC208.12 (I0)
unnamed: IC211.6 (O), IC211.9 (I0)
unnamed: IC211.10 (I1), IC211.11 (O)
unnamed: IC216.10 (I1), IC216.11 (O)
unnamed: IC216.6 (O), IC216.9 (I0)
unnamed: IC216.3 (O), IC216.4 (I0), IC216.12 (I0)
unnamed: IC211.8 (O), IC216.1 (I0), IC216.13 (I1)
unnamed: IC209.6 (O), IC209.9 (I0)
unnamed: IC209.10 (I1), IC209.11 (O)
unnamed: IC209.3 (O), IC209.4 (I0), IC209.12 (I0)
unnamed: IC212.6 (O), IC212.9 (I0)
unnamed: IC212.10 (I1), IC212.11 (O)
unnamed: IC217.10 (I1), IC217.11 (O)
unnamed: IC217.6 (O), IC217.9 (I0)
unnamed: IC217.3 (O), IC217.4 (I0), IC217.12 (I0)
unnamed: IC212.8 (O), IC217.1 (I0), IC217.13 (I1)
unnamed: IC219.6 (O), IC219.9 (I0)
unnamed: IC219.10 (I1), IC219.11 (O)
unnamed: IC219.3 (O), IC219.4 (I0), IC219.12 (I0)
unnamed: IC218.9 (I0), IC218.10 (I1), IC219.8 (O), IC220.1 (I0), IC220.13 (I1)
unnamed: IC220.6 (O), IC220.9 (I0)
unnamed: IC220.10 (I1), IC220.11 (O)
unnamed: IC221.10 (I1), IC221.11 (O)
unnamed: IC221.6 (O), IC221.9 (I0)
unnamed: IC221.3 (O), IC221.4 (I0), IC221.12 (I0)
unnamed: IC220.8 (O), IC221.1 (I0), IC221.13 (I1)
unnamed: IC207.8 (O), IC210.1 (I0), IC210.13 (I1), IC213.1 (I0), IC213.2 (I1)
unnamed: IC213.6 (O), IC213.10 (I1)
unnamed: IC213.3 (O), IC213.9 (I0)
unnamed: IC208.8 (O), IC211.1 (I0), IC211.13 (I1), IC215.1 (I0), IC215.2 (I1)
unnamed: IC213.11 (O), IC215.5 (I1)
unnamed: IC215.3 (O), IC215.4 (I0)
unnamed: IC215.11 (O), IC218.1 (I0)
unnamed: IC215.8 (O), IC218.2 (I1)
unnamed: IC209.8 (O), IC212.1 (I0), IC212.13 (I1), IC215.12 (I0), IC215.13 (I1)
unnamed: IC218.6 (O), IC218.13 (I1)
unnamed: IC218.8 (O), IC218.12 (I0)
SUB_SEL: IC207.1 (I0), IC207.13 (I1), IC208.1 (I0), IC208.13 (I1), IC209.1 (I0), IC209.13 (I1), IC219.1 (I0), IC219.13 (I1); also elsewhere on the board
SUM4: IC214.8 (O); also elsewhere on the board
SUM5: IC216.8 (O); also elsewhere on the board
SUM6: IC217.8 (O); also elsewhere on the board
SUM7: IC221.8 (O); also elsewhere on the board
VCC: IC207.14 (VCC), IC208.14 (VCC), IC209.14 (VCC), IC210.14 (VCC), IC211.14 (VCC), IC212.14 (VCC), IC213.14 (VCC), IC214.14 (VCC), IC215.14 (VCC), IC216.14 (VCC), IC217.14 (VCC), IC218.14 (VCC), IC219.14 (VCC), IC220.14 (VCC), IC221.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 28, ADDSUB CLU

Parts:
IC222, IC223, IC224, IC225: 74HC00D; SO14

Connections:
ADD_C0: IC222.1 (I0); also elsewhere on the board
ADD_G_N0: IC222.5 (I1); also elsewhere on the board
ADD_G_N1: IC222.13 (I1); also elsewhere on the board
ADD_G_N2: IC223.5 (I1); also elsewhere on the board
ADD_G_N3: IC223.13 (I1); also elsewhere on the board
ADD_G_N4: IC224.5 (I1); also elsewhere on the board
ADD_G_N5: IC224.13 (I1); also elsewhere on the board
ADD_G_N6: IC225.5 (I1); also elsewhere on the board
ADD_G_N7: IC225.13 (I1); also elsewhere on the board
ADD_P0: IC222.2 (I1); also elsewhere on the board
ADD_P1: IC222.10 (I1); also elsewhere on the board
ADD_P2: IC223.2 (I1); also elsewhere on the board
ADD_P3: IC223.10 (I1); also elsewhere on the board
ADD_P4: IC224.2 (I1); also elsewhere on the board
ADD_P5: IC224.10 (I1); also elsewhere on the board
ADD_P6: IC225.2 (I1); also elsewhere on the board
ADD_P7: IC225.10 (I1); also elsewhere on the board
CIN1: IC222.6 (O), IC222.9 (I0); also elsewhere on the board
CIN2: IC222.11 (O), IC223.1 (I0); also elsewhere on the board
CIN3: IC223.6 (O), IC223.9 (I0); also elsewhere on the board
CIN4: IC223.11 (O), IC224.1 (I0); also elsewhere on the board
CIN5: IC224.6 (O), IC224.9 (I0); also elsewhere on the board
CIN6: IC224.11 (O), IC225.1 (I0); also elsewhere on the board
CIN7: IC225.6 (O), IC225.9 (I0); also elsewhere on the board
COUT: IC225.11 (O); also elsewhere on the board
GND: IC222.7 (GND), IC223.7 (GND), IC224.7 (GND), IC225.7 (GND); also elsewhere on the board
unnamed: IC222.8 (O), IC222.12 (I0)
unnamed: IC223.3 (O), IC223.4 (I0)
unnamed: IC223.8 (O), IC223.12 (I0)
unnamed: IC224.3 (O), IC224.4 (I0)
unnamed: IC224.8 (O), IC224.12 (I0)
unnamed: IC225.3 (O), IC225.4 (I0)
unnamed: IC225.8 (O), IC225.12 (I0)
unnamed: IC222.3 (O), IC222.4 (I0)
VCC: IC222.14 (VCC), IC223.14 (VCC), IC224.14 (VCC), IC225.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 29, COMPARE

Parts:
IC1, IC2, IC3, IC4, IC226, IC227, IC228, IC229, IC230, IC231: 74HC00D; SO14

Connections:
CIN7: IC229.1 (I0), IC229.4 (I0); also elsewhere on the board
COUT: IC229.5 (I1), IC229.10 (I1); also elsewhere on the board
GND: IC1.7 (GND), IC2.7 (GND), IC3.7 (GND), IC4.7 (GND), IC226.7 (GND), IC227.7 (GND), IC228.7 (GND), IC229.7 (GND), IC230.7 (GND), IC231.7 (GND); also elsewhere on the board
JMP_EN: IC1.1 (I0), IC1.9 (I0), IC2.1 (I0), IC2.9 (I0), IC3.1 (I0), IC3.9 (I0), IC4.1 (I0), IC231.9 (I0), IC231.12 (I0); also elsewhere on the board
unnamed: IC231.8 (O), IC231.13 (I1)
unnamed: IC1.3 (O), IC1.4 (I0), IC1.5 (I1)
unnamed: IC1.8 (O), IC1.12 (I0), IC1.13 (I1)
unnamed: IC2.3 (O), IC2.4 (I0), IC2.5 (I1)
unnamed: IC2.8 (O), IC2.12 (I0), IC2.13 (I1)
unnamed: IC3.3 (O), IC3.4 (I0), IC3.5 (I1)
unnamed: IC3.8 (O), IC3.12 (I0), IC3.13 (I1)
unnamed: IC4.3 (O), IC4.4 (I0), IC4.5 (I1)
unnamed: IC4.8 (O), IC4.12 (I0)
unnamed: IC226.3 (O), IC226.4 (I0), IC226.5 (I1)
unnamed: IC226.8 (O), IC226.12 (I0), IC226.13 (I1)
unnamed: IC227.3 (O), IC227.4 (I0), IC227.5 (I1)
unnamed: IC227.8 (O), IC227.12 (I0), IC227.13 (I1)
unnamed: IC229.2 (I1), IC229.6 (O), IC229.9 (I0)
unnamed: IC229.8 (O), IC229.13 (I1)
unnamed: IC229.3 (O), IC229.12 (I0)
unnamed: IC230.2 (I1), IC230.6 (O), IC230.9 (I0)
unnamed: IC229.11 (O), IC230.5 (I1), IC230.10 (I1)
unnamed: IC230.8 (O), IC230.13 (I1)
unnamed: IC230.3 (O), IC230.12 (I0)
unnamed: IC227.11 (O), IC228.10 (I1)
unnamed: IC227.6 (O), IC228.9 (I0)
unnamed: IC228.8 (O), IC228.12 (I0), IC228.13 (I1)
unnamed: IC226.11 (O), IC228.2 (I1)
unnamed: IC226.6 (O), IC228.1 (I0)
unnamed: IC228.3 (O), IC228.4 (I0), IC228.5 (I1)
unnamed: IC228.6 (O), IC231.1 (I0)
unnamed: IC228.11 (O), IC231.2 (I1)
unnamed: IC231.3 (O), IC231.4 (I0), IC231.5 (I1)
OP0: IC231.10 (I1); also elsewhere on the board
OP1: IC1.2 (I1); also elsewhere on the board
OP2: IC1.10 (I1); also elsewhere on the board
OP3: IC2.2 (I1); also elsewhere on the board
OPLOW4: IC2.10 (I1)
OPLOW5: IC3.2 (I1)
OPLOW6: IC3.10 (I1)
OPLOW7: IC4.2 (I1)
PCB0: IC231.11 (O); also elsewhere on the board
PCB1: IC1.6 (O); also elsewhere on the board
PCB2: IC1.11 (O); also elsewhere on the board
PCB3: IC2.6 (O); also elsewhere on the board
PCB4: IC2.11 (O); also elsewhere on the board
PCB5: IC3.6 (O); also elsewhere on the board
PCB6: IC3.11 (O); also elsewhere on the board
PCB7: IC4.6 (O); also elsewhere on the board
PCC1: IC4.9 (I0); also elsewhere on the board
PCC2: IC4.11 (O); also elsewhere on the board
PCGN1: IC4.13 (I1); also elsewhere on the board
PCP1: IC4.10 (I1); also elsewhere on the board
SIGN: IC230.11 (O)
SUM0: IC226.1 (I0); also elsewhere on the board
SUM1: IC226.2 (I1); also elsewhere on the board
SUM2: IC226.9 (I0); also elsewhere on the board
SUM3: IC226.10 (I1); also elsewhere on the board
SUM4: IC227.1 (I0); also elsewhere on the board
SUM5: IC227.2 (I1); also elsewhere on the board
SUM6: IC227.9 (I0); also elsewhere on the board
SUM7: IC227.10 (I1), IC230.1 (I0), IC230.4 (I0); also elsewhere on the board
VCC: IC1.14 (VCC), IC2.14 (VCC), IC3.14 (VCC), IC4.14 (VCC), IC226.14 (VCC), IC227.14 (VCC), IC228.14 (VCC), IC229.14 (VCC), IC230.14 (VCC), IC231.14 (VCC); also elsewhere on the board
Z: IC231.6 (O); also elsewhere on the board

Notes on the sheet:
Compare
PC_JMP_MUX

Schematic: main.sch, sheet 30, SHIFT

Parts:
IC232, IC233, IC250, IC251: 74HC00D; SO14
IC234, IC235, IC236, IC237, IC238, IC239, IC240, IC241, IC242, IC243, IC244, IC245, IC246, IC247, IC248, IC249: 74HC125D; SO14

Connections:
A0: IC234.2 (I), IC237.12 (I); also elsewhere on the board
A1: IC234.5 (I), IC237.9 (I); also elsewhere on the board
A2: IC234.9 (I), IC237.5 (I); also elsewhere on the board
A3: IC234.12 (I), IC237.2 (I); also elsewhere on the board
A4: IC235.2 (I), IC236.12 (I); also elsewhere on the board
A5: IC235.5 (I), IC236.9 (I); also elsewhere on the board
A6: IC235.9 (I), IC236.5 (I); also elsewhere on the board
A7: IC232.9 (I0), IC235.12 (I), IC236.2 (I); also elsewhere on the board
DR6: IC249.9 (I), IC250.8 (O)
DR7: IC249.12 (I), IC250.11 (O)
GND: IC232.7 (GND), IC233.7 (GND), IC234.7 (GND), IC235.7 (GND), IC236.7 (GND), IC237.7 (GND), IC238.7 (GND), IC239.7 (GND), IC240.7 (GND), IC241.7 (GND), IC242.7 (GND), IC243.7 (GND), IC244.7 (GND), IC245.7 (GND), IC246.7 (GND), IC247.7 (GND), IC248.7 (GND), IC249.7 (GND), IC250.7 (GND), IC251.7 (GND); also elsewhere on the board
unnamed: IC232.3 (O), IC232.4 (I0), IC232.5 (I1)
unnamed: IC232.6 (O), IC232.10 (I1)
unnamed: IC250.6 (O), IC250.13 (I1)
unnamed: IC232.8 (O), IC232.12 (I0), IC250.9 (I0), IC250.12 (I0)
unnamed: IC250.3 (O), IC250.10 (I1)
unnamed: IC232.13 (I1), IC233.8 (O)
OP0: IC233.4 (I0), IC233.5 (I1), IC238.1 (OE), IC238.4 (OE), IC238.10 (OE), IC238.13 (OE), IC239.1 (OE), IC239.4 (OE), IC239.10 (OE), IC239.13 (OE); also elsewhere on the board
OP1: IC233.12 (I0), IC233.13 (I1), IC246.1 (OE), IC246.4 (OE), IC246.10 (OE), IC246.13 (OE), IC247.1 (OE), IC247.4 (OE), IC247.10 (OE), IC247.13 (OE); also elsewhere on the board
OP2: IC233.9 (I0), IC250.1 (I0), IC250.4 (I0); also elsewhere on the board
OP3: IC233.1 (I0), IC233.2 (I1), IC234.1 (OE), IC234.4 (OE), IC234.10 (OE), IC234.13 (OE), IC235.1 (OE), IC235.4 (OE), IC235.10 (OE), IC235.13 (OE), IC242.1 (OE), IC242.4 (OE), IC242.10 (OE), IC242.13 (OE), IC243.1 (OE), IC243.4 (OE), IC243.10 (OE), IC243.13 (OE); also elsewhere on the board
OPN0: IC233.6 (O), IC240.1 (OE), IC240.4 (OE), IC240.10 (OE), IC240.13 (OE), IC241.1 (OE), IC241.4 (OE), IC241.10 (OE), IC241.13 (OE); also elsewhere on the board
OPN1: IC233.11 (O), IC248.1 (OE), IC248.4 (OE), IC248.10 (OE), IC248.13 (OE), IC249.1 (OE), IC249.4 (OE), IC249.10 (OE), IC249.13 (OE); also elsewhere on the board
OPN2: IC232.2 (I1); also elsewhere on the board
OPN3: IC232.1 (I0), IC233.3 (O), IC236.1 (OE), IC236.4 (OE), IC236.10 (OE), IC236.13 (OE), IC237.1 (OE), IC237.4 (OE), IC237.10 (OE), IC237.13 (OE), IC244.1 (OE), IC244.4 (OE), IC244.10 (OE), IC244.13 (OE), IC245.1 (OE), IC245.4 (OE), IC245.10 (OE), IC245.13 (OE); also elsewhere on the board
REV0C: IC233.10 (I1)
REV0C0: IC234.3 (O), IC236.3 (O), IC238.2 (I)
REV0C1: IC234.6 (O), IC236.6 (O), IC238.5 (I), IC240.2 (I)
REV0C2: IC234.8 (O), IC236.8 (O), IC238.9 (I), IC240.5 (I)
REV0C3: IC234.11 (O), IC236.11 (O), IC238.12 (I), IC240.9 (I)
REV0C4: IC235.3 (O), IC237.3 (O), IC239.2 (I), IC240.12 (I)
REV0C5: IC235.6 (O), IC237.6 (O), IC239.5 (I), IC241.2 (I)
REV0C6: IC235.8 (O), IC237.8 (O), IC239.9 (I), IC241.5 (I)
REV0C7: IC235.11 (O), IC237.11 (O), IC239.12 (I), IC241.9 (I)
SH0C0: IC238.3 (O), IC240.3 (O), IC246.2 (I), IC250.2 (I1)
SH0C1: IC238.6 (O), IC240.6 (O), IC246.5 (I), IC250.5 (I1)
SH0C2: IC238.8 (O), IC240.8 (O), IC246.9 (I), IC248.2 (I)
SH0C3: IC238.11 (O), IC240.11 (O), IC246.12 (I), IC248.5 (I)
SH0C4: IC239.3 (O), IC241.3 (O), IC247.2 (I), IC248.9 (I)
SH0C5: IC239.6 (O), IC241.6 (O), IC247.5 (I), IC248.12 (I)
SH0C6: IC239.8 (O), IC241.8 (O), IC247.9 (I), IC249.2 (I)
SH0C7: IC239.11 (O), IC241.11 (O), IC247.12 (I), IC249.5 (I)
SH1C0: IC242.2 (I), IC245.12 (I), IC246.3 (O), IC248.3 (O)
SH1C1: IC242.5 (I), IC245.9 (I), IC246.6 (O), IC248.6 (O)
SH1C2: IC242.9 (I), IC245.5 (I), IC246.8 (O), IC248.8 (O)
SH1C3: IC242.12 (I), IC245.2 (I), IC246.11 (O), IC248.11 (O)
SH1C4: IC243.2 (I), IC244.12 (I), IC247.3 (O), IC249.3 (O)
SH1C5: IC243.5 (I), IC244.9 (I), IC247.6 (O), IC249.6 (O)
SH1C6: IC243.9 (I), IC244.5 (I), IC247.8 (O), IC249.8 (O)
SH1C7: IC243.12 (I), IC244.2 (I), IC247.11 (O), IC249.11 (O)
SHIFT0: IC242.3 (O), IC244.3 (O); also elsewhere on the board
SHIFT1: IC242.6 (O), IC244.6 (O); also elsewhere on the board
SHIFT2: IC242.8 (O), IC244.8 (O); also elsewhere on the board
SHIFT3: IC242.11 (O), IC244.11 (O); also elsewhere on the board
SHIFT4: IC243.3 (O), IC245.3 (O); also elsewhere on the board
SHIFT5: IC243.6 (O), IC245.6 (O); also elsewhere on the board
SHIFT6: IC243.8 (O), IC245.8 (O); also elsewhere on the board
SHIFT7: IC243.11 (O), IC245.11 (O); also elsewhere on the board
SR7: IC232.11 (O), IC241.12 (I)
VCC: IC232.14 (VCC), IC233.14 (VCC), IC234.14 (VCC), IC235.14 (VCC), IC236.14 (VCC), IC237.14 (VCC), IC238.14 (VCC), IC239.14 (VCC), IC240.14 (VCC), IC241.14 (VCC), IC242.14 (VCC), IC243.14 (VCC), IC244.14 (VCC), IC245.14 (VCC), IC246.14 (VCC), IC247.14 (VCC), IC248.14 (VCC), IC249.14 (VCC), IC250.14 (VCC), IC251.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 31, PC_ADDER 0-7

Parts:
IC5, IC6, IC7, IC8, IC9, IC10, IC11, IC252, IC253, IC254, IC255, IC256, IC257, IC258, IC259, IC260, IC261, IC262, IC263, IC264, IC265: 74HC00D; SO14

Connections:
GND: IC5.7 (GND), IC6.7 (GND), IC7.7 (GND), IC8.7 (GND), IC9.7 (GND), IC10.7 (GND), IC11.7 (GND), IC252.7 (GND), IC253.7 (GND), IC254.7 (GND), IC255.7 (GND), IC256.7 (GND), IC257.7 (GND), IC258.7 (GND), IC259.7 (GND), IC260.7 (GND), IC261.7 (GND), IC262.7 (GND), IC263.7 (GND), IC264.7 (GND), IC265.7 (GND); also elsewhere on the board
unnamed: IC7.8 (O), IC7.12 (I0), IC8.1 (I0)
unnamed: IC10.6 (O), IC10.9 (I0), IC10.12 (I0)
unnamed: IC253.3 (O), IC253.4 (I0), IC253.9 (I0)
unnamed: IC6.6 (O), IC6.10 (I1)
unnamed: IC6.3 (O), IC6.9 (I0)
unnamed: IC5.8 (O), IC5.13 (I1)
unnamed: IC5.6 (O), IC5.12 (I0)
unnamed: IC255.11 (O), IC256.1 (I0), IC256.4 (I0)
unnamed: IC258.8 (O), IC258.12 (I0), IC259.1 (I0)
unnamed: IC261.6 (O), IC261.9 (I0), IC261.12 (I0)
unnamed: IC264.3 (O), IC264.4 (I0), IC264.9 (I0)
unnamed: IC7.6 (O), IC7.10 (I1)
unnamed: IC6.11 (O), IC7.9 (I0)
unnamed: IC8.11 (O), IC9.4 (I0)
unnamed: IC9.3 (O), IC9.5 (I1)
unnamed: IC7.13 (I1), IC8.3 (O), IC8.4 (I0)
unnamed: IC7.11 (O), IC8.9 (I0)
unnamed: IC8.6 (O), IC8.10 (I1)
unnamed: IC10.3 (O), IC10.5 (I1)
unnamed: IC9.8 (O), IC10.4 (I0)
unnamed: IC11.8 (O), IC252.1 (I0)
unnamed: IC11.11 (O), IC252.2 (I1)
unnamed: IC10.10 (I1), IC10.11 (O), IC11.1 (I0)
unnamed: IC11.3 (O), IC11.5 (I1)
unnamed: IC10.8 (O), IC11.4 (I0)
unnamed: IC253.6 (O), IC254.1 (I0)
unnamed: IC253.11 (O), IC254.2 (I1)
unnamed: IC253.5 (I1), IC253.8 (O), IC253.12 (I0)
unnamed: IC252.6 (O), IC253.1 (I0)
unnamed: IC252.11 (O), IC253.2 (I1)
unnamed: IC258.6 (O), IC258.10 (I1)
unnamed: IC257.11 (O), IC258.9 (I0)
unnamed: IC254.6 (O), IC254.12 (I0)
unnamed: IC254.8 (O), IC254.13 (I1)
unnamed: IC256.8 (O), IC256.13 (I1)
unnamed: IC256.3 (O), IC256.12 (I0)
unnamed: IC256.2 (I1), IC256.6 (O), IC256.9 (I0)
unnamed: IC257.6 (O), IC257.10 (I1)
unnamed: IC257.3 (O), IC257.9 (I0)
unnamed: IC255.8 (O), IC255.13 (I1)
unnamed: IC255.3 (O), IC255.12 (I0)
unnamed: IC258.13 (I1), IC259.3 (O), IC259.4 (I0)
unnamed: IC258.11 (O), IC259.9 (I0)
unnamed: IC259.6 (O), IC259.10 (I1)
unnamed: IC264.5 (I1), IC264.8 (O), IC264.12 (I0)
unnamed: IC260.3 (O), IC260.5 (I1)
unnamed: IC259.11 (O), IC260.4 (I0)
unnamed: IC261.3 (O), IC261.5 (I1)
unnamed: IC260.8 (O), IC261.4 (I0)
unnamed: IC261.10 (I1), IC261.11 (O), IC262.1 (I0)
unnamed: IC261.8 (O), IC262.4 (I0)
unnamed: IC262.3 (O), IC262.5 (I1)
unnamed: IC264.11 (O), IC265.2 (I1)
unnamed: IC264.6 (O), IC265.1 (I0)
unnamed: IC262.11 (O), IC263.2 (I1)
unnamed: IC262.8 (O), IC263.1 (I0)
unnamed: IC265.6 (O), IC265.12 (I0)
unnamed: IC263.6 (O), IC264.1 (I0)
unnamed: IC263.11 (O), IC264.2 (I1)
PCB0: IC5.2 (I1), IC5.10 (I1), IC6.4 (I0), IC6.5 (I1); also elsewhere on the board
PCB1: IC7.2 (I1), IC7.5 (I1), IC9.1 (I0), IC9.2 (I1); also elsewhere on the board
PCB2: IC9.13 (I1), IC10.2 (I1), IC11.12 (I0), IC11.13 (I1); also elsewhere on the board
PCB3: IC252.10 (I1), IC252.13 (I1), IC254.9 (I0), IC254.10 (I1); also elsewhere on the board
PCB4: IC255.5 (I1), IC255.10 (I1), IC257.4 (I0), IC257.5 (I1); also elsewhere on the board
PCB5: IC258.2 (I1), IC258.5 (I1), IC260.1 (I0), IC260.2 (I1); also elsewhere on the board
PCB6: IC260.13 (I1), IC261.2 (I1), IC262.12 (I0), IC262.13 (I1); also elsewhere on the board
PCB7: IC263.10 (I1), IC263.13 (I1), IC265.9 (I0), IC265.10 (I1); also elsewhere on the board
PCBN7: IC265.8 (O), IC265.13 (I1); also elsewhere on the board
PCC1: IC8.2 (I1), IC8.5 (I1); also elsewhere on the board
PCC2: IC10.13 (I1), IC11.2 (I1); also elsewhere on the board
PCC3: IC253.10 (I1), IC253.13 (I1); also elsewhere on the board
PCC4: IC256.5 (I1), IC256.10 (I1); also elsewhere on the board
PCC5: IC259.2 (I1), IC259.5 (I1); also elsewhere on the board
PCC6: IC261.13 (I1), IC262.2 (I1); also elsewhere on the board
PCC7: IC264.10 (I1), IC264.13 (I1); also elsewhere on the board
PCGN0: IC5.3 (O), IC5.5 (I1), IC5.9 (I0); also elsewhere on the board
PCGN1: IC6.13 (I1), IC7.3 (O), IC7.4 (I0); also elsewhere on the board
PCGN2: IC9.10 (I1), IC9.11 (O), IC10.1 (I0); also elsewhere on the board
PCGN3: IC252.5 (I1), IC252.8 (O), IC252.12 (I0); also elsewhere on the board
PCGN4: IC255.2 (I1), IC255.6 (O), IC255.9 (I0); also elsewhere on the board
PCGN5: IC257.13 (I1), IC258.3 (O), IC258.4 (I0); also elsewhere on the board
PCGN6: IC260.10 (I1), IC260.11 (O), IC261.1 (I0); also elsewhere on the board
PCGN7: IC263.5 (I1), IC263.8 (O), IC263.12 (I0); also elsewhere on the board
PCP0: IC6.8 (O)
PCP1: IC9.6 (O); also elsewhere on the board
PCP2: IC252.3 (O); also elsewhere on the board
PCP3: IC254.11 (O); also elsewhere on the board
PCP4: IC257.8 (O); also elsewhere on the board
PCP5: IC260.6 (O); also elsewhere on the board
PCP6: IC263.3 (O); also elsewhere on the board
PCP7: IC265.11 (O); also elsewhere on the board
PC_PRE_JAB0: IC5.11 (O); also elsewhere on the board
PC_PRE_JAB1: IC8.8 (O); also elsewhere on the board
PC_PRE_JAB2: IC11.6 (O); also elsewhere on the board
PC_PRE_JAB3: IC254.3 (O); also elsewhere on the board
PC_PRE_JAB4: IC256.11 (O); also elsewhere on the board
PC_PRE_JAB5: IC259.8 (O); also elsewhere on the board
PC_PRE_JAB6: IC262.6 (O); also elsewhere on the board
PC_PRE_JAB7: IC265.3 (O); also elsewhere on the board
PC_REG0: IC5.1 (I0), IC5.4 (I0), IC6.1 (I0), IC6.2 (I1); also elsewhere on the board
PC_REG1: IC6.12 (I0), IC7.1 (I0), IC8.12 (I0), IC8.13 (I1); also elsewhere on the board
PC_REG2: IC9.9 (I0), IC9.12 (I0), IC11.9 (I0), IC11.10 (I1); also elsewhere on the board
PC_REG3: IC252.4 (I0), IC252.9 (I0), IC254.4 (I0), IC254.5 (I1); also elsewhere on the board
PC_REG4: IC255.1 (I0), IC255.4 (I0), IC257.1 (I0), IC257.2 (I1); also elsewhere on the board
PC_REG5: IC257.12 (I0), IC258.1 (I0), IC259.12 (I0), IC259.13 (I1); also elsewhere on the board
PC_REG6: IC260.9 (I0), IC260.12 (I0), IC262.9 (I0), IC262.10 (I1); also elsewhere on the board
PC_REG7: IC263.4 (I0), IC263.9 (I0), IC265.4 (I0), IC265.5 (I1); also elsewhere on the board
VCC: IC5.14 (VCC), IC6.14 (VCC), IC7.14 (VCC), IC8.14 (VCC), IC9.14 (VCC), IC10.14 (VCC), IC11.14 (VCC), IC252.14 (VCC), IC253.14 (VCC), IC254.14 (VCC), IC255.14 (VCC), IC256.14 (VCC), IC257.14 (VCC), IC258.14 (VCC), IC259.14 (VCC), IC260.14 (VCC), IC261.14 (VCC), IC262.14 (VCC), IC263.14 (VCC), IC264.14 (VCC), IC265.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 32, PC_ADDER 8-15

Parts:
IC266, IC267, IC268, IC269, IC270, IC271, IC272, IC273, IC274, IC275, IC276, IC277, IC278, IC279, IC280, IC281, IC282, IC283, IC284, IC285: 74HC00D; SO14

Connections:
GND: IC266.7 (GND), IC267.7 (GND), IC268.7 (GND), IC269.7 (GND), IC270.7 (GND), IC271.7 (GND), IC272.7 (GND), IC273.7 (GND), IC274.7 (GND), IC275.7 (GND), IC276.7 (GND), IC277.7 (GND), IC278.7 (GND), IC279.7 (GND), IC280.7 (GND), IC281.7 (GND), IC282.7 (GND), IC283.7 (GND), IC284.7 (GND), IC285.7 (GND); also elsewhere on the board
unnamed: IC285.8 (O), IC285.12 (I0)
unnamed: IC266.11 (O), IC267.1 (I0), IC267.4 (I0)
unnamed: IC269.6 (O), IC269.9 (I0), IC269.12 (I0)
unnamed: IC271.11 (O), IC272.1 (I0), IC272.4 (I0)
unnamed: IC274.6 (O), IC274.9 (I0), IC274.12 (I0)
unnamed: IC276.11 (O), IC277.1 (I0), IC277.4 (I0)
unnamed: IC279.6 (O), IC279.9 (I0), IC279.12 (I0)
unnamed: IC281.11 (O), IC282.1 (I0), IC282.4 (I0)
unnamed: IC282.2 (I1), IC282.6 (O), IC282.9 (I0)
unnamed: IC282.8 (O), IC282.13 (I1)
unnamed: IC282.3 (O), IC282.12 (I0)
unnamed: IC279.10 (I1), IC279.11 (O), IC280.1 (I0)
unnamed: IC280.3 (O), IC280.5 (I1)
unnamed: IC279.8 (O), IC280.4 (I0)
unnamed: IC284.6 (O), IC284.9 (I0), IC284.12 (I0)
unnamed: IC283.8 (O), IC284.4 (I0)
unnamed: IC284.3 (O), IC284.5 (I1)
unnamed: IC281.8 (O), IC281.13 (I1)
unnamed: IC281.3 (O), IC281.12 (I0)
unnamed: IC283.10 (I1), IC283.11 (O), IC284.1 (I0)
unnamed: IC284.10 (I1), IC284.11 (O), IC285.1 (I0)
unnamed: IC283.3 (O), IC283.4 (I0)
unnamed: IC278.8 (O), IC279.4 (I0)
unnamed: IC279.3 (O), IC279.5 (I1)
unnamed: IC285.3 (O), IC285.5 (I1)
unnamed: IC284.8 (O), IC285.4 (I0)
unnamed: IC280.8 (O), IC280.12 (I0)
unnamed: IC266.8 (O), IC266.13 (I1)
unnamed: IC266.3 (O), IC266.12 (I0)
unnamed: IC268.3 (O), IC268.4 (I0)
unnamed: IC267.2 (I1), IC267.6 (O), IC267.9 (I0)
unnamed: IC267.3 (O), IC267.12 (I0)
unnamed: IC267.8 (O), IC267.13 (I1)
unnamed: IC270.8 (O), IC270.12 (I0)
unnamed: IC269.3 (O), IC269.5 (I1)
unnamed: IC268.8 (O), IC269.4 (I0)
unnamed: IC269.10 (I1), IC269.11 (O), IC270.1 (I0)
unnamed: IC269.8 (O), IC270.4 (I0)
unnamed: IC270.3 (O), IC270.5 (I1)
unnamed: IC271.3 (O), IC271.12 (I0)
unnamed: IC271.8 (O), IC271.13 (I1)
unnamed: IC272.2 (I1), IC272.6 (O), IC272.9 (I0)
unnamed: IC272.3 (O), IC272.12 (I0)
unnamed: IC272.8 (O), IC272.13 (I1)
unnamed: IC273.3 (O), IC273.4 (I0)
unnamed: IC273.8 (O), IC274.4 (I0)
unnamed: IC274.3 (O), IC274.5 (I1)
unnamed: IC274.10 (I1), IC274.11 (O), IC275.1 (I0)
unnamed: IC274.8 (O), IC275.4 (I0)
unnamed: IC275.3 (O), IC275.5 (I1)
unnamed: IC275.8 (O), IC275.12 (I0)
unnamed: IC278.3 (O), IC278.4 (I0)
unnamed: IC276.8 (O), IC276.13 (I1)
unnamed: IC276.3 (O), IC276.12 (I0)
unnamed: IC277.2 (I1), IC277.6 (O), IC277.9 (I0)
unnamed: IC277.3 (O), IC277.12 (I0)
unnamed: IC277.8 (O), IC277.13 (I1)
PCB7: IC266.5 (I1), IC266.10 (I1), IC268.13 (I1), IC269.2 (I1), IC271.5 (I1), IC271.10 (I1), IC273.13 (I1), IC274.2 (I1), IC276.5 (I1), IC276.10 (I1), IC278.13 (I1), IC279.2 (I1), IC281.5 (I1), IC281.10 (I1), IC283.13 (I1), IC284.2 (I1); also elsewhere on the board
PCBN7: IC268.5 (I1), IC270.13 (I1), IC273.5 (I1), IC275.13 (I1), IC278.5 (I1), IC280.13 (I1), IC283.5 (I1); also elsewhere on the board
PCC2: IC285.9 (I0); also elsewhere on the board
PCC3: IC285.11 (O); also elsewhere on the board
PCC8: IC267.5 (I1), IC267.10 (I1); also elsewhere on the board
PCC9: IC269.13 (I1), IC270.2 (I1); also elsewhere on the board
PCC10: IC272.5 (I1), IC272.10 (I1); also elsewhere on the board
PCC11: IC274.13 (I1), IC275.2 (I1); also elsewhere on the board
PCC12: IC277.5 (I1), IC277.10 (I1); also elsewhere on the board
PCC13: IC279.13 (I1), IC280.2 (I1); also elsewhere on the board
PCC14: IC282.5 (I1), IC282.10 (I1); also elsewhere on the board
PCC15: IC284.13 (I1), IC285.2 (I1); also elsewhere on the board
PCGN2: IC285.13 (I1); also elsewhere on the board
PCGN8: IC266.2 (I1), IC266.6 (O), IC266.9 (I0); also elsewhere on the board
PCGN9: IC268.10 (I1), IC268.11 (O), IC269.1 (I0); also elsewhere on the board
PCGN10: IC271.2 (I1), IC271.6 (O), IC271.9 (I0); also elsewhere on the board
PCGN11: IC273.10 (I1), IC273.11 (O), IC274.1 (I0); also elsewhere on the board
PCGN12: IC276.2 (I1), IC276.6 (O), IC276.9 (I0); also elsewhere on the board
PCGN13: IC278.10 (I1), IC278.11 (O), IC279.1 (I0); also elsewhere on the board
PCGN14: IC281.2 (I1), IC281.6 (O), IC281.9 (I0); also elsewhere on the board
PCP2: IC285.10 (I1); also elsewhere on the board
PCP8: IC268.6 (O); also elsewhere on the board
PCP9: IC270.11 (O); also elsewhere on the board
PCP10: IC273.6 (O); also elsewhere on the board
PCP11: IC275.11 (O); also elsewhere on the board
PCP12: IC278.6 (O); also elsewhere on the board
PCP13: IC280.11 (O); also elsewhere on the board
PCP14: IC283.6 (O); also elsewhere on the board
PC_PRE_JAB8: IC267.11 (O); also elsewhere on the board
PC_PRE_JAB9: IC270.6 (O); also elsewhere on the board
PC_PRE_JAB10: IC272.11 (O); also elsewhere on the board
PC_PRE_JAB11: IC275.6 (O); also elsewhere on the board
PC_PRE_JAB12: IC277.11 (O); also elsewhere on the board
PC_PRE_JAB13: IC280.6 (O); also elsewhere on the board
PC_PRE_JAB14: IC282.11 (O); also elsewhere on the board
PC_PRE_JAB15: IC285.6 (O); also elsewhere on the board
PC_REG8: IC266.1 (I0), IC266.4 (I0), IC268.1 (I0), IC268.2 (I1); also elsewhere on the board
PC_REG9: IC268.9 (I0), IC268.12 (I0), IC270.9 (I0), IC270.10 (I1); also elsewhere on the board
PC_REG10: IC271.1 (I0), IC271.4 (I0), IC273.1 (I0), IC273.2 (I1); also elsewhere on the board
PC_REG11: IC273.9 (I0), IC273.12 (I0), IC275.9 (I0), IC275.10 (I1); also elsewhere on the board
PC_REG12: IC276.1 (I0), IC276.4 (I0), IC278.1 (I0), IC278.2 (I1); also elsewhere on the board
PC_REG13: IC278.9 (I0), IC278.12 (I0), IC280.9 (I0), IC280.10 (I1); also elsewhere on the board
PC_REG14: IC281.1 (I0), IC281.4 (I0), IC283.1 (I0), IC283.2 (I1); also elsewhere on the board
PC_REG15: IC283.9 (I0), IC283.12 (I0); also elsewhere on the board
VCC: IC266.14 (VCC), IC267.14 (VCC), IC268.14 (VCC), IC269.14 (VCC), IC270.14 (VCC), IC271.14 (VCC), IC272.14 (VCC), IC273.14 (VCC), IC274.14 (VCC), IC275.14 (VCC), IC276.14 (VCC), IC277.14 (VCC), IC278.14 (VCC), IC279.14 (VCC), IC280.14 (VCC), IC281.14 (VCC), IC282.14 (VCC), IC283.14 (VCC), IC284.14 (VCC), IC285.14 (VCC); also elsewhere on the board
