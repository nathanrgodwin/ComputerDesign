# Repository nathanrgodwin/ComputerDesign (continued)

## EAGLE design Eagle/main.brd (continued)

Schematic: main.sch, sheet 40, rega mux

Parts:
IC382, IC400, IC401, IC402, IC403, IC404, IC405, IC406, IC407, IC408, IC409, IC410, IC411, IC412, IC413, IC414: 74HC125D; SO14

Connections:
A4: IC411.3 (O), IC411.6 (O), IC411.8 (O), IC411.11 (O), IC412.3 (O), IC412.6 (O), IC412.8 (O), IC412.11 (O), IC413.3 (O), IC413.6 (O), IC413.8 (O), IC413.11 (O), IC414.3 (O), IC414.6 (O), IC414.8 (O), IC414.11 (O); also elsewhere on the board
A5: IC407.3 (O), IC407.6 (O), IC407.8 (O), IC407.11 (O), IC408.3 (O), IC408.6 (O), IC408.8 (O), IC408.11 (O), IC409.3 (O), IC409.6 (O), IC409.8 (O), IC409.11 (O), IC410.3 (O), IC410.6 (O), IC410.8 (O), IC410.11 (O); also elsewhere on the board
A6: IC403.3 (O), IC403.6 (O), IC403.8 (O), IC403.11 (O), IC404.3 (O), IC404.6 (O), IC404.8 (O), IC404.11 (O), IC405.3 (O), IC405.6 (O), IC405.8 (O), IC405.11 (O), IC406.3 (O), IC406.6 (O), IC406.8 (O), IC406.11 (O); also elsewhere on the board
A7: IC382.3 (O), IC382.6 (O), IC382.8 (O), IC382.11 (O), IC400.3 (O), IC400.6 (O), IC400.8 (O), IC400.11 (O), IC401.3 (O), IC401.6 (O), IC401.8 (O), IC401.11 (O), IC402.3 (O), IC402.6 (O), IC402.8 (O), IC402.11 (O); also elsewhere on the board
GND: IC382.7 (GND), IC400.7 (GND), IC401.7 (GND), IC402.7 (GND), IC403.7 (GND), IC404.7 (GND), IC405.7 (GND), IC406.7 (GND), IC407.7 (GND), IC408.7 (GND), IC409.7 (GND), IC410.7 (GND), IC411.7 (GND), IC412.7 (GND), IC413.7 (GND), IC414.7 (GND); also elsewhere on the board
REG0_4: IC411.2 (I); also elsewhere on the board
REG0_5: IC407.2 (I); also elsewhere on the board
REG0_6: IC403.2 (I); also elsewhere on the board
REG0_7: IC382.2 (I); also elsewhere on the board
REG1_4: IC411.5 (I); also elsewhere on the board
REG1_5: IC407.5 (I); also elsewhere on the board
REG1_6: IC403.5 (I); also elsewhere on the board
REG1_7: IC382.5 (I); also elsewhere on the board
REG2_4: IC411.9 (I); also elsewhere on the board
REG2_5: IC407.9 (I); also elsewhere on the board
REG2_6: IC403.9 (I); also elsewhere on the board
REG2_7: IC382.9 (I); also elsewhere on the board
REG3_4: IC411.12 (I); also elsewhere on the board
REG3_5: IC407.12 (I); also elsewhere on the board
REG3_6: IC403.12 (I); also elsewhere on the board
REG3_7: IC382.12 (I); also elsewhere on the board
REG4_4: IC412.2 (I); also elsewhere on the board
REG4_5: IC408.2 (I); also elsewhere on the board
REG4_6: IC404.2 (I); also elsewhere on the board
REG4_7: IC400.2 (I); also elsewhere on the board
REG5_4: IC412.5 (I); also elsewhere on the board
REG5_5: IC408.5 (I); also elsewhere on the board
REG5_6: IC404.5 (I); also elsewhere on the board
REG5_7: IC400.5 (I); also elsewhere on the board
REG6_4: IC412.9 (I); also elsewhere on the board
REG6_5: IC408.9 (I); also elsewhere on the board
REG6_6: IC404.9 (I); also elsewhere on the board
REG6_7: IC400.9 (I); also elsewhere on the board
REG7_4: IC412.12 (I); also elsewhere on the board
REG7_5: IC408.12 (I); also elsewhere on the board
REG7_6: IC404.12 (I); also elsewhere on the board
REG7_7: IC400.12 (I); also elsewhere on the board
REG8_4: IC413.2 (I); also elsewhere on the board
REG8_5: IC409.2 (I); also elsewhere on the board
REG8_6: IC405.2 (I); also elsewhere on the board
REG8_7: IC401.2 (I); also elsewhere on the board
REG9_4: IC413.5 (I); also elsewhere on the board
REG9_5: IC409.5 (I); also elsewhere on the board
REG9_6: IC405.5 (I); also elsewhere on the board
REG9_7: IC401.5 (I); also elsewhere on the board
REG10_4: IC413.9 (I); also elsewhere on the board
REG10_5: IC409.9 (I); also elsewhere on the board
REG10_6: IC405.9 (I); also elsewhere on the board
REG10_7: IC401.9 (I); also elsewhere on the board
REG11_4: IC413.12 (I); also elsewhere on the board
REG11_5: IC409.12 (I); also elsewhere on the board
REG11_6: IC405.12 (I); also elsewhere on the board
REG11_7: IC401.12 (I); also elsewhere on the board
REG12_4: IC414.2 (I); also elsewhere on the board
REG12_5: IC410.2 (I); also elsewhere on the board
REG12_6: IC406.2 (I); also elsewhere on the board
REG12_7: IC402.2 (I); also elsewhere on the board
REG13_4: IC414.5 (I); also elsewhere on the board
REG13_5: IC410.5 (I); also elsewhere on the board
REG13_6: IC406.5 (I); also elsewhere on the board
REG13_7: IC402.5 (I); also elsewhere on the board
REG14_4: IC414.9 (I); also elsewhere on the board
REG14_5: IC410.9 (I); also elsewhere on the board
REG14_6: IC406.9 (I); also elsewhere on the board
REG14_7: IC402.9 (I); also elsewhere on the board
REG15_4: IC414.12 (I); also elsewhere on the board
REG15_5: IC410.12 (I); also elsewhere on the board
REG15_6: IC406.12 (I); also elsewhere on the board
REG15_7: IC402.12 (I); also elsewhere on the board
RSELA0: IC382.1 (OE), IC403.1 (OE), IC407.1 (OE), IC411.1 (OE); also elsewhere on the board
RSELA1: IC382.4 (OE), IC403.4 (OE), IC407.4 (OE), IC411.4 (OE); also elsewhere on the board
RSELA2: IC382.10 (OE), IC403.10 (OE), IC407.10 (OE), IC411.10 (OE); also elsewhere on the board
RSELA3: IC382.13 (OE), IC403.13 (OE), IC407.13 (OE), IC411.13 (OE); also elsewhere on the board
RSELA4: IC400.1 (OE), IC404.1 (OE), IC408.1 (OE), IC412.1 (OE); also elsewhere on the board
RSELA5: IC400.4 (OE), IC404.4 (OE), IC408.4 (OE), IC412.4 (OE); also elsewhere on the board
RSELA6: IC400.10 (OE), IC404.10 (OE), IC408.10 (OE), IC412.10 (OE); also elsewhere on the board
RSELA7: IC400.13 (OE), IC404.13 (OE), IC408.13 (OE), IC412.13 (OE); also elsewhere on the board
RSELA8: IC401.1 (OE), IC405.1 (OE), IC409.1 (OE), IC413.1 (OE); also elsewhere on the board
RSELA9: IC401.4 (OE), IC405.4 (OE), IC409.4 (OE), IC413.4 (OE); also elsewhere on the board
RSELA10: IC401.10 (OE), IC405.10 (OE), IC409.10 (OE), IC413.10 (OE); also elsewhere on the board
RSELA11: IC401.13 (OE), IC405.13 (OE), IC409.13 (OE), IC413.13 (OE); also elsewhere on the board
RSELA12: IC402.1 (OE), IC406.1 (OE), IC410.1 (OE), IC414.1 (OE); also elsewhere on the board
RSELA13: IC402.4 (OE), IC406.4 (OE), IC410.4 (OE), IC414.4 (OE); also elsewhere on the board
RSELA14: IC402.10 (OE), IC406.10 (OE), IC410.10 (OE), IC414.10 (OE); also elsewhere on the board
RSELA15: IC402.13 (OE), IC406.13 (OE), IC410.13 (OE), IC414.13 (OE); also elsewhere on the board
VCC: IC382.14 (VCC), IC400.14 (VCC), IC401.14 (VCC), IC402.14 (VCC), IC403.14 (VCC), IC404.14 (VCC), IC405.14 (VCC), IC406.14 (VCC), IC407.14 (VCC), IC408.14 (VCC), IC409.14 (VCC), IC410.14 (VCC), IC411.14 (VCC), IC412.14 (VCC), IC413.14 (VCC), IC414.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 41, rega mux

Parts:
IC415, IC416, IC417, IC418, IC419, IC420, IC421, IC422, IC423, IC424, IC425, IC426, IC427, IC428, IC429, IC430: 74HC125D; SO14

Connections:
A0: IC427.3 (O), IC427.6 (O), IC427.8 (O), IC427.11 (O), IC428.3 (O), IC428.6 (O), IC428.8 (O), IC428.11 (O), IC429.3 (O), IC429.6 (O), IC429.8 (O), IC429.11 (O), IC430.3 (O), IC430.6 (O), IC430.8 (O), IC430.11 (O); also elsewhere on the board
A1: IC423.3 (O), IC423.6 (O), IC423.8 (O), IC423.11 (O), IC424.3 (O), IC424.6 (O), IC424.8 (O), IC424.11 (O), IC425.3 (O), IC425.6 (O), IC425.8 (O), IC425.11 (O), IC426.3 (O), IC426.6 (O), IC426.8 (O), IC426.11 (O); also elsewhere on the board
A2: IC419.3 (O), IC419.6 (O), IC419.8 (O), IC419.11 (O), IC420.3 (O), IC420.6 (O), IC420.8 (O), IC420.11 (O), IC421.3 (O), IC421.6 (O), IC421.8 (O), IC421.11 (O), IC422.3 (O), IC422.6 (O), IC422.8 (O), IC422.11 (O); also elsewhere on the board
A3: IC415.3 (O), IC415.6 (O), IC415.8 (O), IC415.11 (O), IC416.3 (O), IC416.6 (O), IC416.8 (O), IC416.11 (O), IC417.3 (O), IC417.6 (O), IC417.8 (O), IC417.11 (O), IC418.3 (O), IC418.6 (O), IC418.8 (O), IC418.11 (O); also elsewhere on the board
GND: IC415.7 (GND), IC416.7 (GND), IC417.7 (GND), IC418.7 (GND), IC419.7 (GND), IC420.7 (GND), IC421.7 (GND), IC422.7 (GND), IC423.7 (GND), IC424.7 (GND), IC425.7 (GND), IC426.7 (GND), IC427.7 (GND), IC428.7 (GND), IC429.7 (GND), IC430.7 (GND); also elsewhere on the board
REG0_0: IC427.2 (I); also elsewhere on the board
REG0_1: IC423.2 (I); also elsewhere on the board
REG0_2: IC419.2 (I); also elsewhere on the board
REG0_3: IC415.2 (I); also elsewhere on the board
REG1_0: IC427.5 (I); also elsewhere on the board
REG1_1: IC423.5 (I); also elsewhere on the board
REG1_2: IC419.5 (I); also elsewhere on the board
REG1_3: IC415.5 (I); also elsewhere on the board
REG2_0: IC427.9 (I); also elsewhere on the board
REG2_1: IC423.9 (I); also elsewhere on the board
REG2_2: IC419.9 (I); also elsewhere on the board
REG2_3: IC415.9 (I); also elsewhere on the board
REG3_0: IC427.12 (I); also elsewhere on the board
REG3_1: IC423.12 (I); also elsewhere on the board
REG3_2: IC419.12 (I); also elsewhere on the board
REG3_3: IC415.12 (I); also elsewhere on the board
REG4_0: IC428.2 (I); also elsewhere on the board
REG4_1: IC424.2 (I); also elsewhere on the board
REG4_2: IC420.2 (I); also elsewhere on the board
REG4_3: IC416.2 (I); also elsewhere on the board
REG5_0: IC428.5 (I); also elsewhere on the board
REG5_1: IC424.5 (I); also elsewhere on the board
REG5_2: IC420.5 (I); also elsewhere on the board
REG5_3: IC416.5 (I); also elsewhere on the board
REG6_0: IC428.9 (I); also elsewhere on the board
REG6_1: IC424.9 (I); also elsewhere on the board
REG6_2: IC420.9 (I); also elsewhere on the board
REG6_3: IC416.9 (I); also elsewhere on the board
REG7_0: IC428.12 (I); also elsewhere on the board
REG7_1: IC424.12 (I); also elsewhere on the board
REG7_2: IC420.12 (I); also elsewhere on the board
REG7_3: IC416.12 (I); also elsewhere on the board
REG8_0: IC429.2 (I); also elsewhere on the board
REG8_1: IC425.2 (I); also elsewhere on the board
REG8_2: IC421.2 (I); also elsewhere on the board
REG8_3: IC417.2 (I); also elsewhere on the board
REG9_0: IC429.5 (I); also elsewhere on the board
REG9_1: IC425.5 (I); also elsewhere on the board
REG9_2: IC421.5 (I); also elsewhere on the board
REG9_3: IC417.5 (I); also elsewhere on the board
REG10_0: IC429.9 (I); also elsewhere on the board
REG10_1: IC425.9 (I); also elsewhere on the board
REG10_2: IC421.9 (I); also elsewhere on the board
REG10_3: IC417.9 (I); also elsewhere on the board
REG11_0: IC429.12 (I); also elsewhere on the board
REG11_1: IC425.12 (I); also elsewhere on the board
REG11_2: IC421.12 (I); also elsewhere on the board
REG11_3: IC417.12 (I); also elsewhere on the board
REG12_0: IC430.2 (I); also elsewhere on the board
REG12_1: IC426.2 (I); also elsewhere on the board
REG12_2: IC422.2 (I); also elsewhere on the board
REG12_3: IC418.2 (I); also elsewhere on the board
REG13_0: IC430.5 (I); also elsewhere on the board
REG13_1: IC426.5 (I); also elsewhere on the board
REG13_2: IC422.5 (I); also elsewhere on the board
REG13_3: IC418.5 (I); also elsewhere on the board
REG14_0: IC430.9 (I); also elsewhere on the board
REG14_1: IC426.9 (I); also elsewhere on the board
REG14_2: IC422.9 (I); also elsewhere on the board
REG14_3: IC418.9 (I); also elsewhere on the board
REG15_0: IC430.12 (I); also elsewhere on the board
REG15_1: IC426.12 (I); also elsewhere on the board
REG15_2: IC422.12 (I); also elsewhere on the board
REG15_3: IC418.12 (I); also elsewhere on the board
RSELA0: IC415.1 (OE), IC419.1 (OE), IC423.1 (OE), IC427.1 (OE); also elsewhere on the board
RSELA1: IC415.4 (OE), IC419.4 (OE), IC423.4 (OE), IC427.4 (OE); also elsewhere on the board
RSELA2: IC415.10 (OE), IC419.10 (OE), IC423.10 (OE), IC427.10 (OE); also elsewhere on the board
RSELA3: IC415.13 (OE), IC419.13 (OE), IC423.13 (OE), IC427.13 (OE); also elsewhere on the board
RSELA4: IC416.1 (OE), IC420.1 (OE), IC424.1 (OE), IC428.1 (OE); also elsewhere on the board
RSELA5: IC416.4 (OE), IC420.4 (OE), IC424.4 (OE), IC428.4 (OE); also elsewhere on the board
RSELA6: IC416.10 (OE), IC420.10 (OE), IC424.10 (OE), IC428.10 (OE); also elsewhere on the board
RSELA7: IC416.13 (OE), IC420.13 (OE), IC424.13 (OE), IC428.13 (OE); also elsewhere on the board
RSELA8: IC417.1 (OE), IC421.1 (OE), IC425.1 (OE), IC429.1 (OE); also elsewhere on the board
RSELA9: IC417.4 (OE), IC421.4 (OE), IC425.4 (OE), IC429.4 (OE); also elsewhere on the board
RSELA10: IC417.10 (OE), IC421.10 (OE), IC425.10 (OE), IC429.10 (OE); also elsewhere on the board
RSELA11: IC417.13 (OE), IC421.13 (OE), IC425.13 (OE), IC429.13 (OE); also elsewhere on the board
RSELA12: IC418.1 (OE), IC422.1 (OE), IC426.1 (OE), IC430.1 (OE); also elsewhere on the board
RSELA13: IC418.4 (OE), IC422.4 (OE), IC426.4 (OE), IC430.4 (OE); also elsewhere on the board
RSELA14: IC418.10 (OE), IC422.10 (OE), IC426.10 (OE), IC430.10 (OE); also elsewhere on the board
RSELA15: IC418.13 (OE), IC422.13 (OE), IC426.13 (OE), IC430.13 (OE); also elsewhere on the board
VCC: IC415.14 (VCC), IC416.14 (VCC), IC417.14 (VCC), IC418.14 (VCC), IC419.14 (VCC), IC420.14 (VCC), IC421.14 (VCC), IC422.14 (VCC), IC423.14 (VCC), IC424.14 (VCC), IC425.14 (VCC), IC426.14 (VCC), IC427.14 (VCC), IC428.14 (VCC), IC429.14 (VCC), IC430.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 42, rselb mux

Parts:
IC431, IC432, IC433, IC434, IC435, IC436, IC437, IC438, IC439, IC440, IC441, IC442, IC443, IC444, IC445, IC446: 74HC125D; SO14

Connections:
B4: IC443.3 (O), IC443.6 (O), IC443.8 (O), IC443.11 (O), IC444.3 (O), IC444.6 (O), IC444.8 (O), IC444.11 (O), IC445.3 (O), IC445.6 (O), IC445.8 (O), IC445.11 (O), IC446.3 (O), IC446.6 (O), IC446.8 (O), IC446.11 (O); also elsewhere on the board
B5: IC439.3 (O), IC439.6 (O), IC439.8 (O), IC439.11 (O), IC440.3 (O), IC440.6 (O), IC440.8 (O), IC440.11 (O), IC441.3 (O), IC441.6 (O), IC441.8 (O), IC441.11 (O), IC442.3 (O), IC442.6 (O), IC442.8 (O), IC442.11 (O); also elsewhere on the board
B6: IC435.3 (O), IC435.6 (O), IC435.8 (O), IC435.11 (O), IC436.3 (O), IC436.6 (O), IC436.8 (O), IC436.11 (O), IC437.3 (O), IC437.6 (O), IC437.8 (O), IC437.11 (O), IC438.3 (O), IC438.6 (O), IC438.8 (O), IC438.11 (O); also elsewhere on the board
B7: IC431.3 (O), IC431.6 (O), IC431.8 (O), IC431.11 (O), IC432.3 (O), IC432.6 (O), IC432.8 (O), IC432.11 (O), IC433.3 (O), IC433.6 (O), IC433.8 (O), IC433.11 (O), IC434.3 (O), IC434.6 (O), IC434.8 (O), IC434.11 (O); also elsewhere on the board
GND: IC431.7 (GND), IC432.7 (GND), IC433.7 (GND), IC434.7 (GND), IC435.7 (GND), IC436.7 (GND), IC437.7 (GND), IC438.7 (GND), IC439.7 (GND), IC440.7 (GND), IC441.7 (GND), IC442.7 (GND), IC443.7 (GND), IC444.7 (GND), IC445.7 (GND), IC446.7 (GND); also elsewhere on the board
REG0_4: IC443.2 (I); also elsewhere on the board
REG0_5: IC439.2 (I); also elsewhere on the board
REG0_6: IC435.2 (I); also elsewhere on the board
REG0_7: IC431.2 (I); also elsewhere on the board
REG1_4: IC443.5 (I); also elsewhere on the board
REG1_5: IC439.5 (I); also elsewhere on the board
REG1_6: IC435.5 (I); also elsewhere on the board
REG1_7: IC431.5 (I); also elsewhere on the board
REG2_4: IC443.9 (I); also elsewhere on the board
REG2_5: IC439.9 (I); also elsewhere on the board
REG2_6: IC435.9 (I); also elsewhere on the board
REG2_7: IC431.9 (I); also elsewhere on the board
REG3_4: IC443.12 (I); also elsewhere on the board
REG3_5: IC439.12 (I); also elsewhere on the board
REG3_6: IC435.12 (I); also elsewhere on the board
REG3_7: IC431.12 (I); also elsewhere on the board
REG4_4: IC444.2 (I); also elsewhere on the board
REG4_5: IC440.2 (I); also elsewhere on the board
REG4_6: IC436.2 (I); also elsewhere on the board
REG4_7: IC432.2 (I); also elsewhere on the board
REG5_4: IC444.5 (I); also elsewhere on the board
REG5_5: IC440.5 (I); also elsewhere on the board
REG5_6: IC436.5 (I); also elsewhere on the board
REG5_7: IC432.5 (I); also elsewhere on the board
REG6_4: IC444.9 (I); also elsewhere on the board
REG6_5: IC440.9 (I); also elsewhere on the board
REG6_6: IC436.9 (I); also elsewhere on the board
REG6_7: IC432.9 (I); also elsewhere on the board
REG7_4: IC444.12 (I); also elsewhere on the board
REG7_5: IC440.12 (I); also elsewhere on the board
REG7_6: IC436.12 (I); also elsewhere on the board
REG7_7: IC432.12 (I); also elsewhere on the board
REG8_4: IC445.2 (I); also elsewhere on the board
REG8_5: IC441.2 (I); also elsewhere on the board
REG8_6: IC437.2 (I); also elsewhere on the board
REG8_7: IC433.2 (I); also elsewhere on the board
REG9_4: IC445.5 (I); also elsewhere on the board
REG9_5: IC441.5 (I); also elsewhere on the board
REG9_6: IC437.5 (I); also elsewhere on the board
REG9_7: IC433.5 (I); also elsewhere on the board
REG10_4: IC445.9 (I); also elsewhere on the board
REG10_5: IC441.9 (I); also elsewhere on the board
REG10_6: IC437.9 (I); also elsewhere on the board
REG10_7: IC433.9 (I); also elsewhere on the board
REG11_4: IC445.12 (I); also elsewhere on the board
REG11_5: IC441.12 (I); also elsewhere on the board
REG11_6: IC437.12 (I); also elsewhere on the board
REG11_7: IC433.12 (I); also elsewhere on the board
REG12_4: IC446.2 (I); also elsewhere on the board
REG12_5: IC442.2 (I); also elsewhere on the board
REG12_6: IC438.2 (I); also elsewhere on the board
REG12_7: IC434.2 (I); also elsewhere on the board
REG13_4: IC446.5 (I); also elsewhere on the board
REG13_5: IC442.5 (I); also elsewhere on the board
REG13_6: IC438.5 (I); also elsewhere on the board
REG13_7: IC434.5 (I); also elsewhere on the board
REG14_4: IC446.9 (I); also elsewhere on the board
REG14_5: IC442.9 (I); also elsewhere on the board
REG14_6: IC438.9 (I); also elsewhere on the board
REG14_7: IC434.9 (I); also elsewhere on the board
REG15_4: IC446.12 (I); also elsewhere on the board
REG15_5: IC442.12 (I); also elsewhere on the board
REG15_6: IC438.12 (I); also elsewhere on the board
REG15_7: IC434.12 (I); also elsewhere on the board
RSELA4: IC432.1 (OE), IC436.1 (OE), IC440.1 (OE), IC444.1 (OE); also elsewhere on the board
RSELB0: IC431.1 (OE), IC435.1 (OE), IC439.1 (OE), IC443.1 (OE); also elsewhere on the board
RSELB1: IC431.4 (OE), IC435.4 (OE), IC439.4 (OE), IC443.4 (OE); also elsewhere on the board
RSELB2: IC431.10 (OE), IC435.10 (OE), IC439.10 (OE), IC443.10 (OE); also elsewhere on the board
RSELB3: IC431.13 (OE), IC435.13 (OE), IC439.13 (OE), IC443.13 (OE); also elsewhere on the board
RSELB5: IC432.4 (OE), IC436.4 (OE), IC440.4 (OE), IC444.4 (OE); also elsewhere on the board
RSELB6: IC432.10 (OE), IC436.10 (OE), IC440.10 (OE), IC444.10 (OE); also elsewhere on the board
RSELB7: IC432.13 (OE), IC436.13 (OE), IC440.13 (OE), IC444.13 (OE); also elsewhere on the board
RSELB8: IC433.1 (OE), IC437.1 (OE), IC441.1 (OE), IC445.1 (OE); also elsewhere on the board
RSELB9: IC433.4 (OE), IC437.4 (OE), IC441.4 (OE), IC445.4 (OE); also elsewhere on the board
RSELB10: IC433.10 (OE), IC437.10 (OE), IC441.10 (OE), IC445.10 (OE); also elsewhere on the board
RSELB11: IC433.13 (OE), IC437.13 (OE), IC441.13 (OE), IC445.13 (OE); also elsewhere on the board
RSELB12: IC434.1 (OE), IC438.1 (OE), IC442.1 (OE), IC446.1 (OE); also elsewhere on the board
RSELB13: IC434.4 (OE), IC438.4 (OE), IC442.4 (OE), IC446.4 (OE); also elsewhere on the board
RSELB14: IC434.10 (OE), IC438.10 (OE), IC442.10 (OE), IC446.10 (OE); also elsewhere on the board
RSELB15: IC434.13 (OE), IC438.13 (OE), IC442.13 (OE), IC446.13 (OE); also elsewhere on the board
VCC: IC431.14 (VCC), IC432.14 (VCC), IC433.14 (VCC), IC434.14 (VCC), IC435.14 (VCC), IC436.14 (VCC), IC437.14 (VCC), IC438.14 (VCC), IC439.14 (VCC), IC440.14 (VCC), IC441.14 (VCC), IC442.14 (VCC), IC443.14 (VCC), IC444.14 (VCC), IC445.14 (VCC), IC446.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 43, rselb mux

Parts:
IC449, IC450, IC451, IC452, IC453, IC454, IC455, IC456, IC457, IC458, IC459, IC460, IC461, IC462, IC463, IC464: 74HC125D; SO14

Connections:
B0: IC461.3 (O), IC461.6 (O), IC461.8 (O), IC461.11 (O), IC462.3 (O), IC462.6 (O), IC462.8 (O), IC462.11 (O), IC463.3 (O), IC463.6 (O), IC463.8 (O), IC463.11 (O), IC464.3 (O), IC464.6 (O), IC464.8 (O), IC464.11 (O); also elsewhere on the board
B1: IC457.3 (O), IC457.6 (O), IC457.8 (O), IC457.11 (O), IC458.3 (O), IC458.6 (O), IC458.8 (O), IC458.11 (O), IC459.3 (O), IC459.6 (O), IC459.8 (O), IC459.11 (O), IC460.3 (O), IC460.6 (O), IC460.8 (O), IC460.11 (O); also elsewhere on the board
B2: IC453.3 (O), IC453.6 (O), IC453.8 (O), IC453.11 (O), IC454.3 (O), IC454.6 (O), IC454.8 (O), IC454.11 (O), IC455.3 (O), IC455.6 (O), IC455.8 (O), IC455.11 (O), IC456.3 (O), IC456.6 (O), IC456.8 (O), IC456.11 (O); also elsewhere on the board
B3: IC449.3 (O), IC449.6 (O), IC449.8 (O), IC449.11 (O), IC450.3 (O), IC450.6 (O), IC450.8 (O), IC450.11 (O), IC451.3 (O), IC451.6 (O), IC451.8 (O), IC451.11 (O), IC452.3 (O), IC452.6 (O), IC452.8 (O), IC452.11 (O); also elsewhere on the board
GND: IC449.7 (GND), IC450.7 (GND), IC451.7 (GND), IC452.7 (GND), IC453.7 (GND), IC454.7 (GND), IC455.7 (GND), IC456.7 (GND), IC457.7 (GND), IC458.7 (GND), IC459.7 (GND), IC460.7 (GND), IC461.7 (GND), IC462.7 (GND), IC463.7 (GND), IC464.7 (GND); also elsewhere on the board
REG0_0: IC461.2 (I); also elsewhere on the board
REG0_1: IC457.2 (I); also elsewhere on the board
REG0_2: IC453.2 (I); also elsewhere on the board
REG0_3: IC449.2 (I); also elsewhere on the board
REG1_0: IC461.5 (I); also elsewhere on the board
REG1_1: IC457.5 (I); also elsewhere on the board
REG1_2: IC453.5 (I); also elsewhere on the board
REG1_3: IC449.5 (I); also elsewhere on the board
REG2_0: IC461.9 (I); also elsewhere on the board
REG2_1: IC457.9 (I); also elsewhere on the board
REG2_2: IC453.9 (I); also elsewhere on the board
REG2_3: IC449.9 (I); also elsewhere on the board
REG3_0: IC461.12 (I); also elsewhere on the board
REG3_1: IC457.12 (I); also elsewhere on the board
REG3_2: IC453.12 (I); also elsewhere on the board
REG3_3: IC449.12 (I); also elsewhere on the board
REG4_0: IC462.2 (I); also elsewhere on the board
REG4_1: IC458.2 (I); also elsewhere on the board
REG4_2: IC454.2 (I); also elsewhere on the board
REG4_3: IC450.2 (I); also elsewhere on the board
REG5_0: IC462.5 (I); also elsewhere on the board
REG5_1: IC458.5 (I); also elsewhere on the board
REG5_2: IC454.5 (I); also elsewhere on the board
REG5_3: IC450.5 (I); also elsewhere on the board
REG6_0: IC462.9 (I); also elsewhere on the board
REG6_1: IC458.9 (I); also elsewhere on the board
REG6_2: IC454.9 (I); also elsewhere on the board
REG6_3: IC450.9 (I); also elsewhere on the board
REG7_0: IC462.12 (I); also elsewhere on the board
REG7_1: IC458.12 (I); also elsewhere on the board
REG7_2: IC454.12 (I); also elsewhere on the board
REG7_3: IC450.12 (I); also elsewhere on the board
REG8_0: IC463.2 (I); also elsewhere on the board
REG8_1: IC459.2 (I); also elsewhere on the board
REG8_2: IC455.2 (I); also elsewhere on the board
REG8_3: IC451.2 (I); also elsewhere on the board
REG9_0: IC463.5 (I); also elsewhere on the board
REG9_1: IC459.5 (I); also elsewhere on the board
REG9_2: IC455.5 (I); also elsewhere on the board
REG9_3: IC451.5 (I); also elsewhere on the board
REG10_0: IC463.9 (I); also elsewhere on the board
REG10_1: IC459.9 (I); also elsewhere on the board
REG10_2: IC455.9 (I); also elsewhere on the board
REG10_3: IC451.9 (I); also elsewhere on the board
REG11_0: IC463.12 (I); also elsewhere on the board
REG11_1: IC459.12 (I); also elsewhere on the board
REG11_2: IC455.12 (I); also elsewhere on the board
REG11_3: IC451.12 (I); also elsewhere on the board
REG12_0: IC464.2 (I); also elsewhere on the board
REG12_1: IC460.2 (I); also elsewhere on the board
REG12_2: IC456.2 (I); also elsewhere on the board
REG12_3: IC452.2 (I); also elsewhere on the board
REG13_0: IC464.5 (I); also elsewhere on the board
REG13_1: IC460.5 (I); also elsewhere on the board
REG13_2: IC456.5 (I); also elsewhere on the board
REG13_3: IC452.5 (I); also elsewhere on the board
REG14_0: IC464.9 (I); also elsewhere on the board
REG14_1: IC460.9 (I); also elsewhere on the board
REG14_2: IC456.9 (I); also elsewhere on the board
REG14_3: IC452.9 (I); also elsewhere on the board
REG15_0: IC464.12 (I); also elsewhere on the board
REG15_1: IC460.12 (I); also elsewhere on the board
REG15_2: IC456.12 (I); also elsewhere on the board
REG15_3: IC452.12 (I); also elsewhere on the board
RSELB0: IC449.1 (OE), IC453.1 (OE), IC457.1 (OE), IC461.1 (OE); also elsewhere on the board
RSELB1: IC449.4 (OE), IC453.4 (OE), IC457.4 (OE), IC461.4 (OE); also elsewhere on the board
RSELB2: IC449.10 (OE), IC453.10 (OE), IC457.10 (OE), IC461.10 (OE); also elsewhere on the board
RSELB3: IC449.13 (OE), IC453.13 (OE), IC457.13 (OE), IC461.13 (OE); also elsewhere on the board
RSELB4: IC450.1 (OE), IC454.1 (OE), IC458.1 (OE), IC462.1 (OE); also elsewhere on the board
RSELB5: IC450.4 (OE), IC454.4 (OE), IC458.4 (OE), IC462.4 (OE); also elsewhere on the board
RSELB6: IC450.10 (OE), IC454.10 (OE), IC458.10 (OE), IC462.10 (OE); also elsewhere on the board
RSELB7: IC450.13 (OE), IC454.13 (OE), IC458.13 (OE), IC462.13 (OE); also elsewhere on the board
RSELB8: IC451.1 (OE), IC455.1 (OE), IC459.1 (OE), IC463.1 (OE); also elsewhere on the board
RSELB9: IC451.4 (OE), IC455.4 (OE), IC459.4 (OE), IC463.4 (OE); also elsewhere on the board
RSELB10: IC451.10 (OE), IC455.10 (OE), IC459.10 (OE), IC463.10 (OE); also elsewhere on the board
RSELB11: IC451.13 (OE), IC455.13 (OE), IC459.13 (OE), IC463.13 (OE); also elsewhere on the board
RSELB12: IC452.1 (OE), IC456.1 (OE), IC460.1 (OE), IC464.1 (OE); also elsewhere on the board
RSELB13: IC452.4 (OE), IC456.4 (OE), IC460.4 (OE), IC464.4 (OE); also elsewhere on the board
RSELB14: IC452.10 (OE), IC456.10 (OE), IC460.10 (OE), IC464.10 (OE); also elsewhere on the board
RSELB15: IC452.13 (OE), IC456.13 (OE), IC460.13 (OE), IC464.13 (OE); also elsewhere on the board
VCC: IC449.14 (VCC), IC450.14 (VCC), IC451.14 (VCC), IC452.14 (VCC), IC453.14 (VCC), IC454.14 (VCC), IC455.14 (VCC), IC456.14 (VCC), IC457.14 (VCC), IC458.14 (VCC), IC459.14 (VCC), IC460.14 (VCC), IC461.14 (VCC), IC462.14 (VCC), IC463.14 (VCC), IC464.14 (VCC); also elsewhere on the board

Schematic: main.sch, sheet 44

Parts:
IC465, IC466, IC470, IC471, IC475, IC476, IC477, IC478: 74HC125D; SO14

Connections:
ADD_SEL_N: IC466.4 (OE), IC471.4 (OE), IC476.4 (OE), IC478.4 (OE); also elsewhere on the board
AND4: IC477.5 (I); also elsewhere on the board
AND5: IC470.5 (I); also elsewhere on the board
AND6: IC475.5 (I); also elsewhere on the board
AND7: IC465.5 (I); also elsewhere on the board
AND_SEL_N: IC465.4 (OE), IC470.4 (OE), IC475.4 (OE), IC477.4 (OE); also elsewhere on the board
CMDN0: IC465.1 (OE), IC470.1 (OE), IC475.1 (OE), IC477.1 (OE); also elsewhere on the board
CMDN7: IC466.13 (OE), IC471.13 (OE), IC476.13 (OE), IC478.13 (OE); also elsewhere on the board
DATA4: IC477.3 (O), IC477.6 (O), IC477.8 (O), IC477.11 (O), IC478.3 (O), IC478.6 (O), IC478.8 (O), IC478.11 (O)
DATA5: IC470.3 (O), IC470.6 (O), IC470.8 (O), IC470.11 (O), IC471.3 (O), IC471.6 (O), IC471.8 (O), IC471.11 (O)
DATA6: IC475.3 (O), IC475.6 (O), IC475.8 (O), IC475.11 (O), IC476.3 (O), IC476.6 (O), IC476.8 (O), IC476.11 (O)
DATA7: IC465.3 (O), IC465.6 (O), IC465.8 (O), IC465.11 (O), IC466.3 (O), IC466.6 (O), IC466.8 (O), IC466.11 (O)
GND: IC465.7 (GND), IC466.7 (GND), IC470.7 (GND), IC471.7 (GND), IC475.7 (GND), IC476.7 (GND), IC477.7 (GND), IC478.7 (GND); also elsewhere on the board
NOT4: IC477.9 (I); also elsewhere on the board
NOT5: IC470.9 (I); also elsewhere on the board
NOT6: IC475.9 (I); also elsewhere on the board
NOT7: IC465.9 (I); also elsewhere on the board
NOT_SEL_N: IC465.10 (OE), IC470.10 (OE), IC475.10 (OE), IC477.10 (OE); also elsewhere on the board
OP4: IC478.12 (I); also elsewhere on the board
OP5: IC471.12 (I); also elsewhere on the board
OP6: IC476.12 (I); also elsewhere on the board
OP7: IC466.12 (I); also elsewhere on the board
OR4: IC477.12 (I); also elsewhere on the board
OR5: IC470.12 (I); also elsewhere on the board
OR6: IC475.12 (I); also elsewhere on the board
OR7: IC465.12 (I); also elsewhere on the board
OR_SEL_N: IC465.13 (OE), IC470.13 (OE), IC475.13 (OE), IC477.13 (OE); also elsewhere on the board
PROD4: IC477.2 (I); also elsewhere on the board
PROD5: IC470.2 (I); also elsewhere on the board
PROD6: IC475.2 (I); also elsewhere on the board
PROD7: IC465.2 (I); also elsewhere on the board
SHIFT4: IC478.9 (I); also elsewhere on the board
SHIFT5: IC471.9 (I); also elsewhere on the board
SHIFT6: IC476.9 (I); also elsewhere on the board
SHIFT7: IC466.9 (I); also elsewhere on the board
SHIFT_SEL_N: IC466.10 (OE), IC471.10 (OE), IC476.10 (OE), IC478.10 (OE); also elsewhere on the board
SUM4: IC478.5 (I); also elsewhere on the board
SUM5: IC471.5 (I); also elsewhere on the board
SUM6: IC476.5 (I); also elsewhere on the board
SUM7: IC466.5 (I); also elsewhere on the board
VCC: IC465.14 (VCC), IC466.14 (VCC), IC470.14 (VCC), IC471.14 (VCC), IC475.14 (VCC), IC476.14 (VCC), IC477.14 (VCC), IC478.14 (VCC); also elsewhere on the board
XOR4: IC478.2 (I); also elsewhere on the board
XOR5: IC471.2 (I); also elsewhere on the board
XOR6: IC476.2 (I); also elsewhere on the board
XOR7: IC466.2 (I); also elsewhere on the board
XOR_SEL_N: IC466.1 (OE), IC471.1 (OE), IC476.1 (OE), IC478.1 (OE); also elsewhere on the board

Schematic: main.sch, sheet 45

Parts:
IC467, IC468, IC469, IC479, IC480, IC481, IC482, IC483, IC484, IC485, IC486: 74HC125D; SO14

Connections:
ADD_SEL_N: IC468.4 (OE), IC479.4 (OE), IC484.4 (OE), IC486.4 (OE); also elsewhere on the board
AND0: IC485.5 (I); also elsewhere on the board
AND1: IC469.5 (I); also elsewhere on the board
AND2: IC483.5 (I); also elsewhere on the board
AND3: IC467.5 (I); also elsewhere on the board
AND_SEL_N: IC467.4 (OE), IC469.4 (OE), IC483.4 (OE), IC485.4 (OE); also elsewhere on the board
CMDN0: IC467.1 (OE), IC469.1 (OE), IC483.1 (OE), IC485.1 (OE); also elsewhere on the board
CMDN7: IC468.13 (OE), IC479.13 (OE), IC484.13 (OE), IC486.13 (OE); also elsewhere on the board
DATA0: IC485.3 (O), IC485.6 (O), IC485.8 (O), IC485.11 (O), IC486.3 (O), IC486.6 (O), IC486.8 (O), IC486.11 (O)
DATA1: IC469.3 (O), IC469.6 (O), IC469.8 (O), IC469.11 (O), IC479.3 (O), IC479.6 (O), IC479.8 (O), IC479.11 (O)
DATA2: IC483.3 (O), IC483.6 (O), IC483.8 (O), IC483.11 (O), IC484.3 (O), IC484.6 (O), IC484.8 (O), IC484.11 (O)
DATA3: IC467.3 (O), IC467.6 (O), IC467.8 (O), IC467.11 (O), IC468.3 (O), IC468.6 (O), IC468.8 (O), IC468.11 (O)
GND: IC467.7 (GND), IC468.7 (GND), IC469.7 (GND), IC479.7 (GND), IC480.7 (GND), IC481.7 (GND), IC482.7 (GND), IC483.7 (GND), IC484.7 (GND), IC485.7 (GND), IC486.7 (GND); also elsewhere on the board
NOT0: IC485.9 (I); also elsewhere on the board
NOT1: IC469.9 (I); also elsewhere on the board
NOT2: IC483.9 (I); also elsewhere on the board
NOT3: IC467.9 (I); also elsewhere on the board
NOT_SEL_N: IC467.10 (OE), IC469.10 (OE), IC483.10 (OE), IC485.10 (OE); also elsewhere on the board
OP0: IC486.12 (I); also elsewhere on the board
OP1: IC479.12 (I); also elsewhere on the board
OP2: IC484.12 (I); also elsewhere on the board
OP3: IC468.12 (I); also elsewhere on the board
OR0: IC485.12 (I); also elsewhere on the board
OR1: IC469.12 (I); also elsewhere on the board
OR2: IC483.12 (I); also elsewhere on the board
OR3: IC467.12 (I); also elsewhere on the board
OR_SEL_N: IC467.13 (OE), IC469.13 (OE), IC483.13 (OE), IC485.13 (OE); also elsewhere on the board
PROD0: IC485.2 (I); also elsewhere on the board
PROD1: IC469.2 (I); also elsewhere on the board
PROD2: IC483.2 (I); also elsewhere on the board
PROD3: IC467.2 (I); also elsewhere on the board
SHIFT0: IC486.9 (I); also elsewhere on the board
SHIFT1: IC479.9 (I); also elsewhere on the board
SHIFT2: IC484.9 (I); also elsewhere on the board
SHIFT3: IC468.9 (I); also elsewhere on the board
SHIFT_SEL_N: IC468.10 (OE), IC479.10 (OE), IC484.10 (OE), IC486.10 (OE); also elsewhere on the board
SUM0: IC486.5 (I); also elsewhere on the board
SUM1: IC479.5 (I); also elsewhere on the board
SUM2: IC484.5 (I); also elsewhere on the board
SUM3: IC468.5 (I); also elsewhere on the board
VCC: IC467.14 (VCC), IC468.14 (VCC), IC469.14 (VCC), IC479.14 (VCC), IC480.14 (VCC), IC481.14 (VCC), IC482.14 (VCC), IC483.14 (VCC), IC484.14 (VCC), IC485.14 (VCC), IC486.14 (VCC); also elsewhere on the board
XOR0: IC486.2 (I); also elsewhere on the board
XOR1: IC479.2 (I); also elsewhere on the board
XOR2: IC484.2 (I); also elsewhere on the board
XOR3: IC468.2 (I); also elsewhere on the board
XOR_SEL_N: IC468.1 (OE), IC479.1 (OE), IC484.1 (OE), IC486.1 (OE); also elsewhere on the board
